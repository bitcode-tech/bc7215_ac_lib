#include "bc7215_ac_lib.h"
#include <string.h>
#define dieecgizrxee  0
#define xclzxnzrkvdh   1
struct vsghnouiwbyk;
struct tbacqdqyhzjl;
struct pktfcxxfncig;
struct lieoifkbswcz;
struct srbjiaxreyht;
union extraValue_t;
static void ujgpijslocme(const struct pktfcxxfncig* coblviwgccvs);
static void gefhjoxgjdgt(const struct vsghnouiwbyk* cssjkjaqtock);
static void qswuykmdmlug(const struct vsghnouiwbyk* cssjkjaqtock);
static void mfvmvvsrgpmq(uint8_t mekzztbhyjqh[][BC7215_MAX_RX_DATA_SIZE], bc7215DataVarPkt_t* ulvlopcjlbnz, const struct vsghnouiwbyk* cssjkjaqtock);
static void musinwgvcyci(const struct vsghnouiwbyk* cssjkjaqtock);
static uint8_t nnkrhrkeffev(uint8_t byte);
static void ckbvbvcobbdk(const struct vsghnouiwbyk* cssjkjaqtock, bc7215DataVarPkt_t* ulvlopcjlbnz);
static bc7215DataMaxPkt_t	exhfmkybxmek;
static bc7215DataMaxPkt_t	iukuxevqncnf;
static bc7215DataMaxPkt_t	nheotrjqxqej;
static bc7215DataMaxPkt_t	ojsszplvqtdq;
static bc7215DataMaxPkt_t	eokpcvziyoim;
static bc7215FormatPkt_t	dayyhlonocwg;
static bc7215FormatPkt_t   tuptfpuregsc;
static bc7215FormatPkt_t   lbytyamdflsf;
static bc7215FormatPkt_t	zakxuesnfusb;
static uint8_t nhbvuvmcmmez[4][BC7215_MAX_RX_DATA_SIZE];
static uint8_t gqikxxqqjecf[4][BC7215_MAX_RX_DATA_SIZE];
static int16_t pasvjyeomvil = -1;
static uint8_t ymndlmvtogxm;
static uint8_t umynxtxlzfya;
static uint8_t keozgtickeih;
static struct pktfcxxfncig* jixidamdohep;
static uint8_t daileifiahoj[4];
static int8_t awafvcglyvyh[4];
static bc7215CombinedMsg_t seuhgjhlwgpz = {0,{.msg={.fmt=NULL, .datPkt=NULL}}};
static const struct vsghnouiwbyk* ylalbobacimq;
static bool altProtocolUsing;
static bool formatLoaded;
static bool secFmtLoaded;
static bool fahrenheitInit = false;
static bool pktLenChanged;
static uint8_t cdceqlsppczl = 25;
static uint8_t nwafzsyodvlc = 78;
int msg, pnum;
static const uint8_t gtlmwdqemewe[8] = { 0xff, 0x01, 0x03, 0x07, 0x0f, 0x1f, 0x3f, 0x7f };
static const uint8_t zcrduqdktess[8] = { 0xff, 0x80, 0xc0, 0xe0, 0xf0, 0xf8, 0xfc, 0xfe };
static const uint8_t qblmsoegqftp[4] = { 0x03, 0x0c, 0x30, 0xc0 };
static const uint8_t qrrxjwzecfmd[8] = { 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80 };
static const uint8_t lxlfwpcgkpnw[16] = { 0x00, 0x02, 0x01, 0x03, 0x08, 0x0a, 0x09, 0x0b, 0x04, 0x06, 0x05, 0x07, 0x0c, 0x0e, 0x0d, 0x0f };
static const uint8_t tqvtyeimyhpa[16] = { 0, 0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07, 0x0f };
static const uint8_t uwxqupuffcsf[16] = { 0, 0x01, 0x01, 0x02, 0x01, 0x02, 0x02, 0x03, 0x01, 0x02, 0x02, 0x03, 0x02, 0x03, 0x03, 0x04 };
typedef struct lieoifkbswcz { uint8_t		mcddolhbanax;
uint8_t		ovadtjwxdzya;
uint8_t		maltsbbficvg;
uint8_t		afuqqmowbboa;
const uint8_t*	hgdodzdmndla;
} lieoifkbswcz;
typedef struct srbjiaxreyht { uint8_t     wehefbyxzswp;
uint8_t     mcddolhbanax;
uint8_t     ovadtjwxdzya;
uint8_t     maltsbbficvg;
const uint8_t*    swagwauldrhl;
} srbjiaxreyht;
typedef union extraValue_t { struct { uint8_t		tqcqagtvxxob;
uint8_t		fpledlehjcsb;
uint8_t		nqsbunmitfrc;
uint8_t		wtivyemmzoju;
uint8_t		pllehvocejgu;
uint8_t		trwurmhtrcaw;
const srbjiaxreyht*  rvrkwqgflpkv;
} set;
struct { uint8_t		ajjjmzrpupbr;
uint8_t		omjfkxvhhonk;
uint8_t		hfpcwtjvihrp;
uint8_t		nrwqlgauweyx;
} kbuoarkttzag;
} extraValue_t;
struct fehyfyrgmlkh { const srbjiaxreyht*		hffaidvvtesl;
const struct vsghnouiwbyk*	cssjkjaqtock;
uint8_t 	gukarciyihed;
uint8_t		qiplgeopecdc;
};
struct utzzewolswpc { struct { uint8_t	   isosilhghoqn : 4;
uint8_t		enrplqfjlsgv : 4;
} mekzztbhyjqh;
uint8_t 	ovadtjwxdzya;
uint8_t		bits;
};
typedef void (*setExtBase_t)(const bc7215DataVarPkt_t* , const bc7215FormatPkt_t*);
union offBits_t { struct { struct utzzewolswpc  yeltdjdwiegk;
struct utzzewolswpc  umavhyptrjjy;
} xdvjpfttnymn;
const bc7215DataVarPkt_t* jylyhhlxgchq;
const bc7215CombinedMsg_t*      fvcxyspulwwt;
const setExtBase_t		dmfwafbbczce;
};
struct pktfcxxfncig { uint8_t		bkpjwqksrjra;
uint8_t		rrcbdmmkoaaz;
int8_t		tqcxlbpdyumb;
uint8_t		ssllwqinqzab;
struct { uint8_t		enrplqfjlsgv : 5;
uint8_t    mvvblxopjmnl : 1;
uint8_t		byte : 1;
uint8_t     pvtybtildlxz  : 1;
} enrplqfjlsgv;
int8_t		fqalxysuvvwm;
int8_t		tkplxpajzfyb;
uint8_t		zdtqqwtikayi;
uint8_t		wiizqupdjedy;
};
typedef bool (*algorithm_t)(const struct vsghnouiwbyk* cssjkjaqtock, const struct pktfcxxfncig* coblviwgccvs, bool ahyzslokqilb);
struct tbacqdqyhzjl { algorithm_t lkwfsmdlhdgq;
const struct pktfcxxfncig* coblviwgccvs;
};
struct wscodbmjbktx { const int8_t*	iqhduifjeusb;
lieoifkbswcz			vzkqjiprdpjc;
};
struct vsghnouiwbyk { struct { uint8_t xhxfnnwqvdiy  : 1;
uint8_t nxyggwlkynwr : 1;
uint8_t    ymmnbayvgjbe : 1;
uint8_t      haibeofkrlkw : 1;
uint8_t  zqbpbblioehh : 1;
uint8_t cmdkwamqxjvi : 1;
uint8_t  scedlvelzavc : 1;
} spec;
uint8_t  signature;
uint16_t bitLen;
uint16_t kbuoarkttzag[4];
lieoifkbswcz  urotzxmebdry;
lieoifkbswcz  rozfsolwsfzh;
lieoifkbswcz  ofajzwessiol;
lieoifkbswcz  wlujocdbskis;
const extraValue_t*  urjrhromzium;
union offBits_t	lzjiegmlwhzf;
const struct tbacqdqyhzjl* watvzlijecjx;
const struct wscodbmjbktx*	nhaqybpfptll;
};
struct sxpegamfsrfd { struct vsghnouiwbyk	cssjkjaqtock;
const void* 				hffaidvvtesl;
};
static uint8_t nnkrhrkeffev(uint8_t byte);
static void uubekixzgshu(const struct vsghnouiwbyk* cssjkjaqtock);
static bool jjnbcsyhvcga(const struct vsghnouiwbyk* cssjkjaqtock);
static uint8_t quwejoiijpow(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return ikxelzwhutjc+pfsohnkuokbo;
} static uint8_t sqqdwrvojnfo(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return ikxelzwhutjc^pfsohnkuokbo;
} static uint8_t cfyvoxvhfsjc(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return ikxelzwhutjc&pfsohnkuokbo;
} static uint8_t uqyhlclfaqvf(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return ikxelzwhutjc|pfsohnkuokbo;
} static uint8_t jygqbyirznuw(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return pfsohnkuokbo<<ikxelzwhutjc;
} static uint8_t npdszpkyaeok(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return pfsohnkuokbo>>ikxelzwhutjc;
} static uint8_t zbffnomatwig(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return ikxelzwhutjc-pfsohnkuokbo;
} static uint8_t ilvnuufzrmrx(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { uint8_t ujbxqjypguet = ((pfsohnkuokbo&0x0f)+(pfsohnkuokbo>>4))&0x0f;
if (ujbxqjypguet & 0x08) { ujbxqjypguet |= 0xf0;
} return ikxelzwhutjc+ujbxqjypguet;
} static uint8_t mnfshirkttvb(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { (void)ikxelzwhutjc;
return pfsohnkuokbo;
} static uint8_t ilibynmzdizy(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return ikxelzwhutjc&(~pfsohnkuokbo);
} static uint8_t vjmoucltcxxm (uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return ((ikxelzwhutjc&0xf0)+(pfsohnkuokbo&0xf0)) | ((ikxelzwhutjc+pfsohnkuokbo)&0x0f);
} static uint8_t ctwpjffpgdcx(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return ikxelzwhutjc+nnkrhrkeffev(pfsohnkuokbo);
} static uint8_t vnestuazyanw(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return ikxelzwhutjc-nnkrhrkeffev(pfsohnkuokbo);
} static uint8_t zzkyfwrddmdb(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { return ikxelzwhutjc+uwxqupuffcsf[pfsohnkuokbo>>4]+uwxqupuffcsf[pfsohnkuokbo&0x0f];
} static uint8_t bflowncvliwg(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { (void)pfsohnkuokbo;
return ~ikxelzwhutjc;
} static uint8_t foihsinohqsf(uint8_t ikxelzwhutjc, uint8_t pfsohnkuokbo) { (void)ikxelzwhutjc;
return (pfsohnkuokbo<<4)|(pfsohnkuokbo>>4);
} typedef uint8_t (*calFunc_t)(uint8_t, uint8_t);
static const calFunc_t mjxneimtqttw[] = { quwejoiijpow, sqqdwrvojnfo, cfyvoxvhfsjc, uqyhlclfaqvf, jygqbyirznuw, npdszpkyaeok, zbffnomatwig, ilvnuufzrmrx, mnfshirkttvb, ilibynmzdizy, vjmoucltcxxm, ctwpjffpgdcx, vnestuazyanw, zzkyfwrddmdb, bflowncvliwg, foihsinohqsf };
static uint8_t ztliufaujcyq(uint8_t mekzztbhyjqh, uint8_t ovadtjwxdzya) { if (ovadtjwxdzya&0x01) { return nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2]&0x0f;
} else { return nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2]>>4;
} } static void zrsbvldeqnpk(uint8_t mekzztbhyjqh, uint8_t ovadtjwxdzya, uint8_t data) { data &= 0x0f;
if (ovadtjwxdzya&0x01) { nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2] = (nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2]&0xf0)|data;
} else { nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2] = (nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2]&0x0f) | (data<<4);
} } static uint8_t qawouhkqsihv(uint8_t mekzztbhyjqh, uint8_t ovadtjwxdzya) { if (ovadtjwxdzya&0x01) { return nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2]>>4;
} else { return nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2]&0x0f;
} } static void qpxcyjppljwd(uint8_t mekzztbhyjqh, uint8_t ovadtjwxdzya, uint8_t data) { data &= 0x0f;
if (ovadtjwxdzya&0x01) { nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2] = (nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2]&0x0f) | (data<<4);
} else { nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2] = (nhbvuvmcmmez[mekzztbhyjqh][ovadtjwxdzya/2]&0xf0)|data;
} } static bool vazisqcodoyh(const struct vsghnouiwbyk* cssjkjaqtock, const struct pktfcxxfncig* coblviwgccvs, bool ahyzslokqilb) { uint8_t mekzztbhyjqh, binbdllxxutl, iigdpskkkics, nibStart, nibEnd;
uint8_t zbsbxrmgwhhr;
uint8_t ikxelzwhutjc, pfsohnkuokbo;
uint8_t dskbycvacpfu;
uint8_t fqalxysuvvwm, targetPos;
binbdllxxutl = coblviwgccvs->bkpjwqksrjra>>4;
iigdpskkkics = coblviwgccvs->bkpjwqksrjra&0x0f;
fqalxysuvvwm = coblviwgccvs->fqalxysuvvwm&0x03;
mekzztbhyjqh = binbdllxxutl;
if (coblviwgccvs->enrplqfjlsgv.mvvblxopjmnl) { dskbycvacpfu = keozgtickeih;
} else { dskbycvacpfu = 0;
} while (mekzztbhyjqh <= iigdpskkkics) { if (mekzztbhyjqh == binbdllxxutl) { nibStart = coblviwgccvs->rrcbdmmkoaaz;
} else { nibStart = 0;
} if (mekzztbhyjqh == iigdpskkkics) { nibEnd = ((cssjkjaqtock->kbuoarkttzag[mekzztbhyjqh]+7)/8)*2-1+coblviwgccvs->tqcxlbpdyumb;
} else { nibEnd = ((cssjkjaqtock->kbuoarkttzag[mekzztbhyjqh]+7)/8)*2-1;
} for (zbsbxrmgwhhr=nibStart; zbsbxrmgwhhr<=nibEnd; zbsbxrmgwhhr=zbsbxrmgwhhr+coblviwgccvs->ssllwqinqzab) {
pfsohnkuokbo = ztliufaujcyq(mekzztbhyjqh, zbsbxrmgwhhr);
if (coblviwgccvs->enrplqfjlsgv.pvtybtildlxz) { ikxelzwhutjc = coblviwgccvs->wiizqupdjedy;
targetPos = zbsbxrmgwhhr+coblviwgccvs->tkplxpajzfyb;
dskbycvacpfu = mjxneimtqttw[coblviwgccvs->enrplqfjlsgv.enrplqfjlsgv](ikxelzwhutjc, pfsohnkuokbo);
dskbycvacpfu &= coblviwgccvs->zdtqqwtikayi;
if (coblviwgccvs->fqalxysuvvwm >= 0) { if (ahyzslokqilb) { dskbycvacpfu = (ztliufaujcyq(fqalxysuvvwm, targetPos)&(~coblviwgccvs->zdtqqwtikayi)) | dskbycvacpfu;
zrsbvldeqnpk(fqalxysuvvwm, targetPos, dskbycvacpfu);
} else { if ((dskbycvacpfu&0x0f) != (ztliufaujcyq(fqalxysuvvwm, targetPos)&(coblviwgccvs->zdtqqwtikayi))) { return false;
} } } } else { ikxelzwhutjc = dskbycvacpfu;
dskbycvacpfu = mjxneimtqttw[coblviwgccvs->enrplqfjlsgv.enrplqfjlsgv](ikxelzwhutjc, pfsohnkuokbo);
} } mekzztbhyjqh++;
} if (!coblviwgccvs->enrplqfjlsgv.pvtybtildlxz) { pfsohnkuokbo = dskbycvacpfu;
ikxelzwhutjc = coblviwgccvs->wiizqupdjedy;
dskbycvacpfu = mjxneimtqttw[coblviwgccvs->zdtqqwtikayi](ikxelzwhutjc,pfsohnkuokbo);
keozgtickeih = dskbycvacpfu;
if (coblviwgccvs->fqalxysuvvwm >= 0) { if (coblviwgccvs->enrplqfjlsgv.byte) { targetPos = (cssjkjaqtock->kbuoarkttzag[fqalxysuvvwm]+7)/8-1+coblviwgccvs->tkplxpajzfyb;
if (ahyzslokqilb) { nhbvuvmcmmez[fqalxysuvvwm][targetPos] = dskbycvacpfu;
} else { return dskbycvacpfu == nhbvuvmcmmez[fqalxysuvvwm][targetPos];
} } else { targetPos = (cssjkjaqtock->kbuoarkttzag[fqalxysuvvwm]+7)/8*2-1+coblviwgccvs->tkplxpajzfyb;
if (ahyzslokqilb) { zrsbvldeqnpk(fqalxysuvvwm, targetPos, dskbycvacpfu&0x0f);
} else { return (dskbycvacpfu&0x0f) == ztliufaujcyq(fqalxysuvvwm, targetPos);
} } } } return true;
} static bool lccydooawqqq(const struct vsghnouiwbyk* cssjkjaqtock, const struct pktfcxxfncig* coblviwgccvs, bool ahyzslokqilb) { uint8_t mekzztbhyjqh, binbdllxxutl, iigdpskkkics, nibStart, nibEnd;
uint8_t zbsbxrmgwhhr;
uint8_t ikxelzwhutjc, pfsohnkuokbo;
uint8_t dskbycvacpfu;
uint8_t fqalxysuvvwm, targetPos;
binbdllxxutl = coblviwgccvs->bkpjwqksrjra>>4;
iigdpskkkics = coblviwgccvs->bkpjwqksrjra&0x0f;
fqalxysuvvwm = coblviwgccvs->fqalxysuvvwm&0x03;
mekzztbhyjqh = binbdllxxutl;
if (coblviwgccvs->enrplqfjlsgv.mvvblxopjmnl) { dskbycvacpfu = keozgtickeih;
} else { dskbycvacpfu = 0;
} while (mekzztbhyjqh <= iigdpskkkics) { if (mekzztbhyjqh == binbdllxxutl) { nibStart = coblviwgccvs->rrcbdmmkoaaz;
} else { nibStart = 0;
} if (mekzztbhyjqh == iigdpskkkics) { nibEnd = ((cssjkjaqtock->kbuoarkttzag[mekzztbhyjqh]+7)/8)*2-1+coblviwgccvs->tqcxlbpdyumb;
} else { nibEnd = ((cssjkjaqtock->kbuoarkttzag[mekzztbhyjqh]+7)/8)*2-1;
} for (zbsbxrmgwhhr=nibStart; zbsbxrmgwhhr<=nibEnd; zbsbxrmgwhhr=zbsbxrmgwhhr+coblviwgccvs->ssllwqinqzab) {
pfsohnkuokbo = qawouhkqsihv(mekzztbhyjqh, zbsbxrmgwhhr);
if (coblviwgccvs->enrplqfjlsgv.pvtybtildlxz) { ikxelzwhutjc = coblviwgccvs->wiizqupdjedy;
targetPos = zbsbxrmgwhhr+coblviwgccvs->tkplxpajzfyb;
dskbycvacpfu = mjxneimtqttw[coblviwgccvs->enrplqfjlsgv.enrplqfjlsgv](ikxelzwhutjc, pfsohnkuokbo);
dskbycvacpfu &= coblviwgccvs->zdtqqwtikayi;
if (coblviwgccvs->fqalxysuvvwm >= 0) { if (ahyzslokqilb) { dskbycvacpfu = (qawouhkqsihv(fqalxysuvvwm, targetPos)&(~coblviwgccvs->zdtqqwtikayi)) | dskbycvacpfu;
qpxcyjppljwd(fqalxysuvvwm, targetPos, dskbycvacpfu);
} else { if (dskbycvacpfu != (qawouhkqsihv(fqalxysuvvwm, targetPos)&(coblviwgccvs->zdtqqwtikayi))) { return false;
} } } } else { ikxelzwhutjc = dskbycvacpfu;
dskbycvacpfu = mjxneimtqttw[coblviwgccvs->enrplqfjlsgv.enrplqfjlsgv](ikxelzwhutjc, pfsohnkuokbo);
} } mekzztbhyjqh++;
} if (!coblviwgccvs->enrplqfjlsgv.pvtybtildlxz) { pfsohnkuokbo = dskbycvacpfu;
ikxelzwhutjc = coblviwgccvs->wiizqupdjedy;
dskbycvacpfu = mjxneimtqttw[coblviwgccvs->zdtqqwtikayi](ikxelzwhutjc,pfsohnkuokbo);
keozgtickeih = dskbycvacpfu;
if (coblviwgccvs->fqalxysuvvwm >= 0) { if (coblviwgccvs->enrplqfjlsgv.byte) { targetPos = (cssjkjaqtock->kbuoarkttzag[fqalxysuvvwm]+7)/8-1+coblviwgccvs->tkplxpajzfyb;
if (ahyzslokqilb) { nhbvuvmcmmez[fqalxysuvvwm][targetPos] = dskbycvacpfu;
} else { return dskbycvacpfu == nhbvuvmcmmez[fqalxysuvvwm][targetPos];
} } else { targetPos = (cssjkjaqtock->kbuoarkttzag[fqalxysuvvwm]+7)/8*2-1+coblviwgccvs->tkplxpajzfyb;
if (ahyzslokqilb) { qpxcyjppljwd(fqalxysuvvwm, targetPos, dskbycvacpfu&0x0f);
} else { return (dskbycvacpfu&0x0f) == qawouhkqsihv(fqalxysuvvwm, targetPos);
} } } } return true;
} static bool egdktbtdutis(const struct vsghnouiwbyk* cssjkjaqtock, const struct pktfcxxfncig* coblviwgccvs, bool ahyzslokqilb) { uint8_t mekzztbhyjqh, binbdllxxutl, iigdpskkkics, byteStart, byteEnd;
uint8_t zbsbxrmgwhhr;
uint8_t ikxelzwhutjc, pfsohnkuokbo;
uint8_t dskbycvacpfu;
uint8_t fqalxysuvvwm, targetPos;
binbdllxxutl = coblviwgccvs->bkpjwqksrjra>>4;
iigdpskkkics = coblviwgccvs->bkpjwqksrjra&0x0f;
fqalxysuvvwm = coblviwgccvs->fqalxysuvvwm&0x03;
mekzztbhyjqh = binbdllxxutl;
if (coblviwgccvs->enrplqfjlsgv.mvvblxopjmnl) { dskbycvacpfu = keozgtickeih;
} else { dskbycvacpfu = 0;
} while (mekzztbhyjqh <= iigdpskkkics) { if (mekzztbhyjqh == binbdllxxutl) { byteStart = coblviwgccvs->rrcbdmmkoaaz;
} else { byteStart = 0;
} if (mekzztbhyjqh == iigdpskkkics) { byteEnd = (cssjkjaqtock->kbuoarkttzag[mekzztbhyjqh]+7)/8-1+coblviwgccvs->tqcxlbpdyumb;
} else { byteEnd = (cssjkjaqtock->kbuoarkttzag[mekzztbhyjqh]+7)/8-1;
} for (zbsbxrmgwhhr=byteStart; zbsbxrmgwhhr<=byteEnd; zbsbxrmgwhhr=zbsbxrmgwhhr+coblviwgccvs->ssllwqinqzab) {
pfsohnkuokbo = nhbvuvmcmmez[mekzztbhyjqh][zbsbxrmgwhhr];
if (coblviwgccvs->enrplqfjlsgv.pvtybtildlxz) { ikxelzwhutjc = coblviwgccvs->wiizqupdjedy;
targetPos = zbsbxrmgwhhr+coblviwgccvs->tkplxpajzfyb;
dskbycvacpfu = mjxneimtqttw[coblviwgccvs->enrplqfjlsgv.enrplqfjlsgv](ikxelzwhutjc, pfsohnkuokbo);
dskbycvacpfu &= coblviwgccvs->zdtqqwtikayi;
if (coblviwgccvs->fqalxysuvvwm >= 0) { if (ahyzslokqilb) { dskbycvacpfu = (nhbvuvmcmmez[fqalxysuvvwm][targetPos]&(~coblviwgccvs->zdtqqwtikayi)) | dskbycvacpfu;
nhbvuvmcmmez[fqalxysuvvwm][targetPos] = dskbycvacpfu;
} else { if (dskbycvacpfu != (nhbvuvmcmmez[fqalxysuvvwm][targetPos]&(coblviwgccvs->zdtqqwtikayi))) { return false;
} } } } else { ikxelzwhutjc = dskbycvacpfu;
dskbycvacpfu = mjxneimtqttw[coblviwgccvs->enrplqfjlsgv.enrplqfjlsgv](ikxelzwhutjc, pfsohnkuokbo);
} } mekzztbhyjqh++;
} if (!coblviwgccvs->enrplqfjlsgv.pvtybtildlxz) { pfsohnkuokbo = dskbycvacpfu;
ikxelzwhutjc = coblviwgccvs->wiizqupdjedy;
dskbycvacpfu = mjxneimtqttw[coblviwgccvs->zdtqqwtikayi](ikxelzwhutjc,pfsohnkuokbo);
keozgtickeih = dskbycvacpfu;
if (coblviwgccvs->fqalxysuvvwm >= 0) { targetPos = (cssjkjaqtock->kbuoarkttzag[fqalxysuvvwm]+7)/8-1+coblviwgccvs->tkplxpajzfyb;
if (ahyzslokqilb) { nhbvuvmcmmez[fqalxysuvvwm][targetPos] = dskbycvacpfu;
} else { return dskbycvacpfu == nhbvuvmcmmez[fqalxysuvvwm][targetPos];
} } } return true;
} static bool rxcxbbegyxhy(const struct vsghnouiwbyk* cssjkjaqtock, const struct pktfcxxfncig* coblviwgccvs, bool ahyzslokqilb) { (void)cssjkjaqtock;
if (ahyzslokqilb) { ujgpijslocme(coblviwgccvs);
} return true;
} static bool eqthmplkqpmk(const struct vsghnouiwbyk* cssjkjaqtock, const struct pktfcxxfncig* coblviwgccvs, bool ahyzslokqilb) { bool dskbycvacpfu;
struct vsghnouiwbyk finjgceabaok;
finjgceabaok.spec = cssjkjaqtock->spec;
finjgceabaok.signature = cssjkjaqtock->signature;
finjgceabaok.bitLen = cssjkjaqtock->bitLen;
finjgceabaok.kbuoarkttzag[0] = cssjkjaqtock->urjrhromzium->kbuoarkttzag.ajjjmzrpupbr;
finjgceabaok.kbuoarkttzag[1] = cssjkjaqtock->urjrhromzium->kbuoarkttzag.omjfkxvhhonk;
finjgceabaok.kbuoarkttzag[2] = cssjkjaqtock->urjrhromzium->kbuoarkttzag.hfpcwtjvihrp;
finjgceabaok.kbuoarkttzag[3] = cssjkjaqtock->urjrhromzium->kbuoarkttzag.nrwqlgauweyx;
qswuykmdmlug(cssjkjaqtock);
gefhjoxgjdgt(cssjkjaqtock);
ckbvbvcobbdk(&finjgceabaok, (bc7215DataVarPkt_t*)&nheotrjqxqej);
dskbycvacpfu = egdktbtdutis(&finjgceabaok, coblviwgccvs, ahyzslokqilb);
qswuykmdmlug(&finjgceabaok);
gefhjoxgjdgt(&finjgceabaok);
ckbvbvcobbdk(cssjkjaqtock, (bc7215DataVarPkt_t*)&nheotrjqxqej);
return dskbycvacpfu;
} static bool bodjhjgyoxhi(const struct vsghnouiwbyk* cssjkjaqtock, const struct pktfcxxfncig* coblviwgccvs, bool ahyzslokqilb) { uint8_t zbsbxrmgwhhr;
(void)ahyzslokqilb;
for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<coblviwgccvs->tqcxlbpdyumb; zbsbxrmgwhhr++)
{ if (nhbvuvmcmmez[coblviwgccvs->bkpjwqksrjra][coblviwgccvs->rrcbdmmkoaaz+zbsbxrmgwhhr] != *(cssjkjaqtock->ofajzwessiol.hgdodzdmndla+zbsbxrmgwhhr)) { return false;
} } return true;
} static void nexkiawgsmhd(const bc7215DataVarPkt_t* lisemfzsvrmg, const bc7215FormatPkt_t* ykzkmazhyybm) { (void)lisemfzsvrmg;
(void)ykzkmazhyybm;
ojsszplvqtdq = exhfmkybxmek;
ojsszplvqtdq.bitLen = ((const struct sxpegamfsrfd*)ylalbobacimq->rozfsolwsfzh.hgdodzdmndla)->cssjkjaqtock.bitLen;
umynxtxlzfya = ymndlmvtogxm;
tuptfpuregsc = dayyhlonocwg;
ojsszplvqtdq.data[19] = 0x01;
ojsszplvqtdq.data[7] = (ojsszplvqtdq.data[7]&0xf0)|0x05;
} static const char*	VERSION = "V7.1 build 2619";
static const uint8_t qlbsybjbuuwq[] =  {0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x2f};
static const uint8_t jlxcxegylhom[] =  {0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x00};
static const uint8_t hzaxbgzfvbgn[] =  {0x16, 0x17, 0x18, 0x19, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x30};
static const uint8_t pqzbdwgjzgjg[] =  {0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d};
static const uint8_t nemjsunvswft[] =  {0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a};
static const uint8_t auwyugwmwlso[] =  {0x0f, 0x0e, 0x0d, 0x0c, 0x0b, 0x0a, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01};
static const uint8_t evrgvsxldwse[] =  {0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A, 0x09};
static const uint8_t hmcmmhtpafcl[] =  {0x0f, 0x1e, 0x2d, 0x3c, 0x4b, 0x5a, 0x69, 0x78, 0x87, 0x96, 0xa5, 0xb4, 0xc3, 0xd2, 0xe1};
static const uint8_t zmuhmziggshb[] =  {0x00, 0x00, 0x08, 0x0c, 0x04, 0x06, 0x0e, 0x0a, 0x02, 0x03, 0x0b, 0x09, 0x01, 0x05, 0x0d, 0x07};
static const uint8_t duzqslhlvrbd[] = {0x10, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02};
static const uint8_t huxsncyaliwc[] = {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x00};
static const uint8_t klgznqqxptrf[] = {0x61, 0x71, 0x81, 0x91, 0x02, 0x12, 0x22, 0x32, 0x42, 0x52, 0x62, 0x72, 0x82, 0x92, 0x03};
static const uint8_t mmaikokpzmiv[] = {0x00, 0x00, 0x01, 0x03, 0x02, 0x06, 0x07, 0x05, 0x04, 0x0c, 0x0d, 0x09, 0x08, 0x0a, 0x0b, 0x0e};
static const uint8_t rnzkhkybayht[] = {0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e};
static const uint8_t sjmbrhgdfrrn[] = {0x19, 0x18, 0x17, 0x16, 0x15, 0x14, 0x13, 0x12, 0x11, 0x10, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B};
static const uint8_t rlymjpnqwqxi[] = {0x0d, 0x0e, 0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b};
static const uint8_t aekximikujqn[] = {0x00, 0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c};
static const uint8_t ybxjhnxfyjgb[] = {0x00, 0x0a, 0x14, 0x1e, 0x28, 0x32, 0x3c, 0x46, 0x50, 0x5a, 0x64, 0x6e, 0x78, 0x82, 0x8c};
static const uint8_t nuyihfymrlxy[] = {0x18, 0x1A, 0x1c, 0x1e, 0x20, 0x22, 0x24, 0x26, 0x28, 0x2a, 0x2c, 0x2e, 0x30, 0x32, 0x34};
static const uint8_t vmrjepqklhrp[] = {0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x00};
static const uint8_t pyxakjclofwa[] = {0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27};
static const uint8_t nvtfnxgsqyky[] = {0x0e, 0x0d, 0x0c, 0x0b, 0x0a, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00};
static const uint8_t hnqfngbztkvd[] = {0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A};
static const uint8_t atzscyghbqee[] = {0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x00};
static const uint8_t dirmsniyzxmk[] = {0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x60};
static const uint8_t xgmfromrdrwl[] = {0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x40};
static const uint8_t lrpkzrzobwqs[] = {0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24};
static const uint8_t dvdpdyuxhulp[] = {0x0f, 0x1e, 0x2d, 0x3c, 0x4b, 0x5a, 0x69, 0x78, 0x87, 0x96, 0xa5, 0xb4, 0xc3, 0xd2, 0xe1};
static const uint8_t jxwvazqfgoxj[] = {0x00, 0x01, 0x03, 0x02, 0x06, 0x07, 0x05, 0x04, 0x0c, 0x0d, 0x0f, 0x0e, 0x0a, 0x0b, 0x09};
static const uint8_t mnqdymgkrwjk[] = {0x42, 0x44, 0x45, 0x47, 0x49, 0x4b, 0x4d, 0x4e, 0x50, 0x52, 0x54, 0x56, 0x57, 0x59, 0x5b};
static const uint8_t ujhihmyhohwg[] = {0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07, 0x0f};
static const uint8_t mcmwdzsspsij[] = {0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x03, 0x00};
static const uint8_t imegbmhoswpz[] = {0x07, 0x0b, 0x03, 0x0d, 0x05, 0x09, 0x01, 0x0e, 0x06, 0x0a, 0x02, 0x0c, 0x04, 0x08, 0x00};
static const uint8_t mscxujnqnuhc[] = {0x00, 0x0f, 0x07, 0x0b, 0x03, 0x0d, 0x05, 0x09, 0x01, 0x0e, 0x06, 0x0a, 0x02, 0x0c, 0x04};
static const uint8_t yqfsdnalmyna[] = {0x08, 0x08, 0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x0d, 0x0d};
static const uint8_t tkgjxmqmrafm[] = {0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19};
static const uint8_t jvyasvocpwas[] = {0x30, 0x32, 0x34, 0x36, 0x38, 0x3A, 0x3C, 0x3E, 0x40, 0x42, 0x44, 0x46, 0x48, 0x4A, 0x4C, 0xC0};
static const uint8_t ughfpjcxzynj[] = {0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2a, 0x2b};
static const uint8_t ekkpcyyobtwh[] = {0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05};
static const uint8_t oaqarbuqcnzi[] = {0x00, 0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07};
static const uint8_t pbcogogavqpp[] = {0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10};
static const uint8_t rzgdiuvzpbzk[] = {0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2a, 0x2b, 0x2c, 0x00};
static const uint8_t qasyaeygoyda[] = {0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x00, 0x01, 0x02, 0x03};
static const uint8_t xpatrucniagd[] = {0x07, 0x07, 0x06, 0x05, 0x04, 0x03, 0x07, 0x06, 0x05, 0x04, 0x03, 0x07, 0x06, 0x05, 0x04};
static const uint8_t nbroaydguqzt[] = {0x09, 0x09, 0x09, 0x09, 0x09, 0x09, 0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0x07, 0x07, 0x07};
static const uint8_t xwpxrjafcuyl[] = {0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06};
static const uint8_t tqqemhnsqtkj[] = {0x30, 0x31, 0x32, 0x33, 0x34, 0x38, 0x39, 0x3a, 0x3b, 0x3c, 0x40, 0x41, 0x42, 0x43, 0x44};
static const uint8_t hsuvxgtgltjj[]  = {0,   1,   4,  2,  3};
static const uint8_t gjckeliagtvm[]  = {0,   1,   0,  2,  3};
static const uint8_t vfbfuutoazdp[]  = {0,   1,   4,  2,  6};
static const uint8_t tajyfdalqtrk[]  = {0,   1,   8,  2,  4};
static const uint8_t vdgjgcoiublr[]  = {0,   1,   3,  2,  4};
static const uint8_t aegickjxmxsj[]  = {4,   2,   1,  3,  5};
static const uint8_t niaotlqdftsv[]  = {8,   3,   1,  2,  7};
static const uint8_t xramcvgpilnw[]  = {1,   0,   3,  2,  2};
static const uint8_t nzrkfuvfonaq[]  = {0,   3,   4,  2,  6};
static const uint8_t fonpcaohdilk[] = {7,   0,   3,  1,  2};
static const uint8_t fumlhnuvtjti[] = {4,   0,   3,  1,  2};
static const uint8_t umjxfsvzcsro[] = {7,   5,   3,  6,  4};
static const uint8_t bafqaozlnera[] = {7,   6,   3,  5,  4};
static const uint8_t usdftdsdonen[] = {7,   6,   3, 0x0a,0x0b};
static const uint8_t eertyilkoola[] = {4,   0,   1,  2,  3};
static const uint8_t ckgvxwpdxdyf[] = {0x13, 0x02, 0x01, 0x03, 0x13};
static const uint8_t gzwyyudcsgwr[] = {8,   4,   8,  2,  1};
static const uint8_t rnuwicqokfnq[] = {0,   2,   6,  4,  8};
static const uint8_t gpjvwopzumaf[] = {1,   2,   4,  0,  8};
static const uint8_t ezdvwkrfawmx[] = {0,   0,   2,  1,  5};
static const uint8_t ajxmlmqzwxcy[] = {6,   2,   4,  3,  0};
static const uint8_t lcfcdrxiqyzz[] = {0,   2,   1,  3,  4};
static const uint8_t rwxhlwtqcuxy[] = {2,   0,   3,  1,  1};
static const uint8_t kfznlnimdous[] = {8,   8, 0x0a, 0x0b,  9};
static const uint8_t shqsgblklcuc[] = {5,   1,   2,  4,  3};
static const uint8_t wrcxnynhcibi[] = {4,   0,   1,  2,  5};
static const uint8_t iquqznqnoydo[] = {3,   1,   3,  2,  2};
static const uint8_t owzoglwzsxda[] = {0,   1,   2,  4,  3};
static const uint8_t ybuezpmusfwy[] = {0,   1,   2,  3,  4};
static const uint8_t yzpeqodnfhra[] = {1,   2,   1,  3,  5};
static const uint8_t tjbeparnujnx[] = {0x42,  0x42, 0xc3,  0x42,  0xc3};
static const uint8_t nbgcalmcrydn[] = {0,   2,   4,  1,  3};
static const uint8_t txsbffnaanwl[] = {0,   8,   4, 0x0c,  0x0c};
static const uint8_t mtqttagzkyvk[] = {2,   0,   4,   1,  3};
static const uint8_t skpwqtbrungz[] = {8,   4,   2,  1,  0};
static const uint8_t einaxguqxgdv[] = {1,   2,   0,  3,  4};
static const uint8_t cxsyqmosciuu[] = {0x23, 5, 0x21,  7,  9};
static const uint8_t ollwywbmbdun[] = {0x0B,  0x06, 0x08,  0x04,  0x02};
static const uint8_t bbdoduitrwbi[] = {2,   2,   1,  3,  0};
static const uint8_t kzndtcqngbci[] = {2,   1,   1,  3,  0};
static const uint8_t jnwrrmemhpqv[] = {9,   9,   1,  5,  0x0d};
static const uint8_t gzobhywjwzgu[] = {9,   6,   1,  5,  0x0d};
static const uint8_t acrrvmmzqyhj[] = {6,   2,   1,  3,  0};
static const uint8_t qkzbyzcluece[] = {0,   3,   1,  2,  7};
static const uint8_t smlahnhsfqyk[] = {3,   1,   2,  5,  0};
static const uint8_t pqvvecicvowt[] = {2,   3,   1,  2,  2};
static const uint8_t cnvzopxnosqn[] = {7,   7,   1,  5,  3};
static const uint8_t tmjxndimiwqv[] = {3,   2,   1,  7,  0};
static const uint8_t gboajlxtrvem[] = {0,   4,   2,  6,  0};
static const uint8_t wxkwcmkryxyu[] = {0,   4,   7,  2,  1};
static const uint8_t iwibokxoamdr[] = {0,   8,   1,  4,  2};
static const uint8_t lejoqyagfyzp[] = {7,   6,   8,  4,  2};
static const uint8_t nzxfabradldm[] = {0,   2,   1,  4,  8};
static const uint8_t ltegqbgfgmvt[] = {0,   4,   3,  1,  2};
static const uint8_t ziszrqxokrda[] = {2,   4,   3,  5,  0x0c};
static const uint8_t rdgxenokefnn[] = {7,   3,   6,  9,  8};
static const uint8_t ygcjwyoxujmy[] = {3,   0,   4,  1,  2};
static const uint8_t etirvoycmsmy[] = {7,   6,   4,  5,  3};
static const uint8_t hlwjchgwhrxt[] = {5,   2,   1,  3,  4};
static const uint8_t cmvjkmxfoogt[] = {1,   3,   4,  2,  6};
static const uint8_t kuynqvlswrys[] = {3,   2,   1,  7,  0};
static const uint8_t sjcyohrqpoaq[] = {0x0a, 2,  8,  1,  4};
static const uint8_t buylqkkswbpc[] = {7,  4,  6,  4,  3};
static const uint8_t wtkljughxyhz[] = {1,  6,  6,  5,  0x0a};
static const uint8_t dhxclxrtlauf[] = {0,  0,  0,  4,  3};
static const uint8_t ewocvipkuzaw[] = {1,  1,  3,  2,  0};
static const uint8_t kmaatknfqqxv[] = {1,  6,  0x0d,  6,  0x0a};
static const uint8_t jwphqmnoiuwo[] = {1,  2,  6,  3,  0};
static const uint8_t sohkunnzjygb[] = {4,  2,  6,  3,  5};
static const uint8_t qzrdkksygiln[] = {1,  1,  1,  1,  1};
static const uint8_t psyzdexniwbw[] = {0x23, 0x03, 0x03, 0x22, 0x21};
static const uint8_t jzebnhioprnt[] = {7,  3,  1,  2,  2};
static const uint8_t cwmdpzszkgpi[] = {0x05, 0x41, 0x24, 0x42, 0x03};
static const uint8_t eoaliifvrjnc[] = {0,  0,  1,  0,  2};
static const uint8_t uhvnpakabflt[] = {0,  0,  2,  4,  6};
static const uint8_t mjzkesqcmxsp[] = {4,  2,  0,  1,  3};
static const uint8_t ddrkrcyvihjd[] = {5,  1,  3,  2,  4};
static const uint8_t dcxgciynobhy[] = {0,  0,  2,  6,  4};
static const uint8_t eidniawnhpyq[] = {1,  2,  4,  3,  5};
static const uint8_t koatbgekibjo[] = {1,  4,  2,  3,  5};
static const uint8_t qqnypqpywrvq[] = {1,  2,  6,  4,  3};
static const uint8_t ltlemtyukwcf[] = {4,  6,  0,  2,  3};
static const uint8_t cuyzhcvurjqp[] = {3,  2,  0,  1,  2};
static const uint8_t ujgogupnevgb[] = {0,  8,  2,  4,  1};
static const uint8_t zoxbzpgkrild[] = {3,  2,  1,  0,  1};
static const uint8_t lnfwnedlkogu[] = {0,  1,  2,  4,  8};
static const uint8_t ueqljpyepgwu[] = {0,  2,  8,  4,  3};
static const uint8_t xwsylmhoratf[] = {0,  4,  0x0c,  8,  4};
static const uint8_t hiqcqegacvct[] = {3,  1,  2,  4,  5};
static const uint8_t lkbvugtuxcmh[] = {0,  2,  1,  2,  3};
static const uint8_t azkyukdfmqqr[] = {3,  1,  0,  2,  4};
static const uint8_t mpbrctckhasl[] = {2,  0,  3,  1,  4};
static const uint8_t hhhswelrvjuh[] = {7,  3,  6,  5,  1};
static const uint8_t mulochthnhgc[] = {0,  3,  1,  3,  4};
static const uint8_t lpolqyvgduhp[] = {0,  2,  3,  2,  4};
static const uint8_t saueijuhxhjx[] = {0x0c,  2,  1,  3,  4};
static const uint8_t rnqrphdpnqzx[] = {8,  0,  1,  2,  4};
static const uint8_t hprejobsvxdc[] = {2,  3,  0,  2,  1};
static const uint8_t pssscpmmpywo[] = {5,  1,  4,  0,  3};
static const uint8_t xodtxovxrqdi[]= {1,  2,  4,  0,  6};
static const uint8_t vsgkdejbfslk[]= {0,  1,  4,  3,  2};
static const uint8_t swbgzrukfhqt[]= {0,  8,  1,  2,  4};
static const uint8_t fpcdqkhazcgk[]= {0,  1,  4,  5,  3};
static const uint8_t vsldpvefbakr[] = { 0,    1,     3,    5, 5};
static const uint8_t tgvozcdkwizi[] = { 0,    1,     2,    3, 3};
static const uint8_t vukdbvtfigfk[] = { 5,    3,     2,    1, 1};
static const uint8_t gwmvscjwshzk[] = { 0,    2,     3,    1, 1};
static const uint8_t xknpcbptryfb[] = { 0,    2,     3,    5, 5};
static const uint8_t xzzewdxxicyp[] = { 0,    2,     0,    4, 4};
static const uint8_t mctpbidjvrsb[] = { 5,    1,     2,    4,  0};
static const uint8_t sodnmplfotvu[] = {0x0a,  3,     5,    7, 7};
static const uint8_t ctwleblehvbl[] = { 0,    1,     2,    4};
static const uint8_t balsfqyllobd[] ={ 7,    3,     2,    1, 1};
static const uint8_t ygdgsrknfpiy[] ={ 0,    3,     2,    1, 1};
static const uint8_t zhfepltcdgom[] ={ 7,    5,     3,    1, 1};
static const uint8_t qogdydoechiy[] ={ 7,    4,     5,    6, 6};
static const uint8_t watlqftdktqz[] ={ 3,    0,     1,    2, 5};
static const uint8_t cdtozclqdgpe[] ={0xFF, 0x20, 0x40, 0x60, 0x60};
static const uint8_t wiesewazwfjj[] ={ 7,    6,     5,    4, 4};
static const uint8_t enfaqllpjsst[] ={ 3,    4,     3,    2, 2};
static const uint8_t mqgcthvkvikd[] ={ 8,    4,     2,    1, 0};
static const uint8_t xoikkvjtpeyh[] ={ 1,    4,     8,    2, 2};
static const uint8_t gezfbtusiggj[] = { 6,    1,    3,    5,  5};
static const uint8_t rxjkcgzrlsjg[] = { 5,    4,     2,    1, 0};
static const uint8_t mveqqstfduyf[] = { 4,    3,     2,    1, 1};
static const uint8_t oobbdzmmtido[] = { 5,    7,     2,   1,  0};
static const uint8_t dyzevacnxdjd[] = { 5,    1,     2,    3, 3};
static const uint8_t eobqxjqhbanf[] = { 4,    6,     5,    7, 4};
static const uint8_t tfyyqgwxvmya[] = { 0,    3,     1,    2, 0};
static const uint8_t klltwbstguam[] = { 0x0a, 4,     6,    7};
static const uint8_t obqdvlxymdam[] = { 0,    8,   0x0c,   4,  2};
static const uint8_t qtpbyvcfejdx[] = { 5,    0,     2,    4, 0};
static const uint8_t lhegdqcihvky[] = {0xff, 0x8a, 0xad, 0xd0, 0xd0};
static const uint8_t riybiayodery[] = {8, 1, 2, 4, 4};
static const uint8_t roldsnmewkty[] = {0x00, 0x0a, 0x32, 0x63, 0x63};
static const uint8_t souulsuvkqvp[] = {3, 2, 1, 0, 0};
static const uint8_t awyoxyekofnl[] = {0x27, 0x17, 0x07, 0x36};
static const uint8_t aorqinwjsvvt[] = {7, 5, 4, 3, 3};
static const uint8_t jvocmwauessk[] = {4, 0, 2, 3};
static const uint8_t tsasjsbzwxie[] = {7, 1, 2, 3, 3};
static const uint8_t ghixxwbtroxk[] = {6, 0, 2, 4, 4};
static const uint8_t xbkwqzgpisrs[] = {7, 5, 3, 2, 2};
static const uint8_t buuehtaguyng[] = {0x0f, 2, 4, 6, 6};
static const uint8_t hmcqxpcagkyb[] = {0, 4, 6, 2, 2};
static const uint8_t ylmeljrhbupr[] = {0, 2, 4, 5, 6};
static const uint8_t pdsivkkogkpw[] = {0, 1, 6, 8, 8};
static const uint8_t tdwegvcedrpe[] = {1, 2, 4, 8, 8};
static const uint8_t cnbszmkdlatp[] = {5, 2, 3, 4, 4};
static const uint8_t zdumkkqrzozd[] = {1, 2, 4, 5, 3};
static const uint8_t xkbkyujymdhn[] = {5, 1, 3, 4, 4};
static const uint8_t hydxpacucott[] = {1, 8, 4, 2, 2};
static const uint8_t exghimrmmgkb[] = {7, 2, 1, 0, 2};
static const uint8_t uyyrvcoowruy[] = {4, 4, 5, 6, 6};
static const uint8_t aqptxectdvef[] = {4, 7, 6, 5};
static const uint8_t plbsqfqwtdxy[] = {0, 3, 7, 5};
static const uint8_t ioyqosfwejrk[] = {0, 2, 6, 5};
static const uint8_t jeqgpekhirgy[] = {0, 3, 4, 5};
static const uint8_t qzwqicrgdjvb[] = {2, 3, 5, 7};
static const uint8_t odzevozycpja[] = {0, 2, 1, 3};
static const uint8_t aglvlpkugvof[] = {1, 2, 3, 4};
static const uint8_t zazdvdrlgoxw[] = {7, 1, 3, 5};
static const uint8_t jiytyamonchm[] = {4, 5, 6, 7};
static const uint8_t jstalkdbnehx[] = {0, 2, 6, 1};
static const uint8_t irftdmkwcmwl[] = {7, 4, 2, 1};
static const uint8_t bqkwjhxmdzlf[] = {3, 1, 2, 0};
static const uint8_t jrumdzqovxoi[] = {0, 2, 1, 8};
static const uint8_t idmdsvmdrdfb[] = {7, 6, 4, 3};
static const uint8_t wlrehuclbzxu[] = {8, 2, 6, 4};
static const uint8_t xadprewnqthb[] = {6, 2, 3, 4, 1};
static const uint8_t qnjhecxddjvg[] = {4, 1, 2, 3};
static const uint8_t ufmvcxxcfxly[] = {3, 3, 1, 0};
static const uint8_t tfnbefmjojvh[]   = {0, 1, 6, 4,  5, 5};
static const uint8_t jprvapuookmy[]   = {3, 4, 1, 5,  0, 0};
static const uint8_t dvtgclyxpwol[] = {0, 1, 3, 3, 0};
static const uint8_t awcyzokqylxb[]   = {3, 3, 0x0c, 3, 0x0b, 3};
static const uint8_t dijowucrnhyr[] = {0x66, 0x28, 0x3c, 0x64, 0x65};
static const uint8_t khirzhpliszk[] = {0x66, 0x14, 0x3c, 0x64, 0x65};
static const uint8_t asymsdykfyoh[]   = {1, 1, 1, 2, 0x0f, 0x0f};
static const uint8_t pvaqlkvrylaf[] = {1, 0, 0, 0, 0};
static const uint8_t vczurmymtuxp[]   = {1, 2, 4, 6, 3, 3};
static const uint8_t qkjrwmuzbyzt[]   = {5, 7, 0x0b, 9, 0x0c, 0x0c};
static const uint8_t dhljfflougxp[]   = {6, 7, 2, 3, 0, 1};
static const uint8_t obdcmcvhlbdy[]   = {5, 4, 6, 2, 7, 7};
static const uint8_t bxstpkifthlt[]  = {2, 2, 6, 0x11, 1, 1};
static const uint8_t zbzgguwefrup[]  = {1, 2, 6, 0x11, 0x25, 0x25};
static const uint8_t zgmshkbdxzgj[]  = {9, 8, 4, 5, 1, 1};
static const uint8_t djntjwrzxoau[]  = {1, 1, 0x0f, 2, 0x0f, 0x0f};
static const uint8_t ggppmvgyklcq[] = {0x5d, 0x5d, 0x41, 0x5d, 0x5d};
static const uint8_t cztawhzyjhpm[] = {1, 1, 0, 1, 1};
static const uint8_t pdymzidejhjm[] = {0xb9, 0xb9, 0x82, 0xb9, 0xb9};
static const uint8_t qdwabnumooho[]  = {0x14, 0x10, 0x08, 0x0c, 0x0c};
static const uint8_t aobugicxmdfl[] = {0x38, 0x38, 0x00, 0x38, 0x38};
static const uint8_t pipnpmrpkedm[]  = {3, 4, 7, 6, 0, 0};
static const uint8_t fevrkzpoqnlu[] = {6, 6, 0, 2, 0};
static const uint8_t vubaykzztfch[] = {0, 0, 1, 1, 0};
static const uint8_t mwkgnbawnupn[]  = {0, 0, 1, 0, 0, 0};
static const uint8_t lzedgpxidpwo[]  = {0x44, 0x43, 0x13, 0x42, 0x13, 0x13};
static const uint8_t ntreoxngymvu[]  = {8, 9, 7, 0x0c, 3, 3};
static const uint8_t dyotlvvkqnpr[] = {0, 0, 0, 0, 0};
static const uint8_t hflaumdbxlvi[]  = {2, 3, 1, 5, 0, 0, 0x16};
static const uint8_t mtfsewvbqxgq[]  = {9, 0x0a, 8, 0x0f, 0, 0};
static const uint8_t mislybzummhh[] = {1, 3, 0, 0, 1};
static const uint8_t lrypgvboynfb[] = {0x80, 0x14, 0x5a, 0x80};
static const uint8_t bhpujprhbbzz[]  = {2, 2, 6, 0x11, 0x25, 0x25};
static const uint8_t ypyrmwtpomqr[]  = {4, 4, 0, 5, 0, 0};
static const uint8_t mznzdziymvik[] = {0x79, 0x79, 0x55, 0x79, 0x79};
static const uint8_t bzkuzronqwts[] = {0x79, 0x79, 0x42, 0x79, 0x79};
static const uint8_t arrgrcqyizqk[]  = {0x0d, 0x0d, 0x09, 0x11, 0x06, 0X06};
static const uint8_t bitfqvjznjnl[]  = {1, 1, 1, 1, 0x0a, 6};
static const uint8_t wowphqlodpqt[]  = {1, 1, 1, 1, 0x0a, 0x0a};
static const uint8_t lmcndmewtobi[] = {0xa7, 0xa7, 0x45, 0x95, 0xa7};
static const uint8_t zkbfjyvupcpk[]  = {4, 4, 4, 4, 5, 5};
static const uint8_t zemiirzsdbky[]  = {0, 0, 0, 0, 1, 1};
static const uint8_t bwmvykmymvdg[]  = {3, 3, 3, 3, 2, 1};
static const uint8_t epeeaeljzebe[]  = {2, 2, 2, 2, 2, 1};
static const uint8_t batckafsxjzu[]  = {0, 0, 0, 0, 2, 1};
static const uint8_t uaghrucblmcx[] = {0, 0, 0, 1, 1};
static const uint8_t ploddrlwbsqf[] = {2, 0, 0, 0, 1};
static const uint8_t enbhuleqjjhe[] = {7, 0, 1, 2};
static const uint8_t gogtxxkhbwxb[] = {1, 2, 2, 0, 2};
static const uint8_t xnxeqdrldfpq[] = {7, 7, 7, 2, 6};
static const uint8_t nplzubhhgday[]  = {0, 0, 3, 4, 0, 0};
static const uint8_t mlkdcgbktsbx[] = {0xf0, 0xf0, 0xc3, 0xb4, 0xf0, 0xf0};
static const uint8_t pwtyykijqszs[] = { 0x00, 0xc0, 0x80, 0x40, 0x00};
static const uint8_t giuuqcfmisoi[] = { 0x02, 0x02, 0x00, 0x02, 0x02};
static const uint8_t webpxtwsguso[] = { 0x07, 0x07, 0x07, 0x05, 0x07};
static const uint8_t ynrccdgwrdaj[] = { 0x80, 0x00, 0x00, 0x00, 0x00};
static const srbjiaxreyht zdmxihfihoyr[] = { {2, 1, 2, 0xe0, pwtyykijqszs}, {0, 0, 0, 0, NULL} };
static const srbjiaxreyht htavyzvrfvan[] = { {2, 1, 2, 0xe0, pwtyykijqszs}, {1, 1, 1, 0x03, giuuqcfmisoi}, {1, 0, 11, 0x07, webpxtwsguso}, {1, 0, 12, 0x80, ynrccdgwrdaj}, {0, 0, 0, 0, NULL} };
static const uint8_t lvgrvcvajddi[] = { 0, 0, 0, 0, 0x04, 0x04};
static const srbjiaxreyht qhwczhuqttir[] = { {3, 1, 0, 0x04, lvgrvcvajddi}, {0, 0, 0, 0, NULL} };
static const uint8_t dmbziueaajmo[] = { 0x00, 0x0, 0x10, 0x00, 0x00};
static const srbjiaxreyht hwwzherdhlek[] = { {1, 0, 9, 0x10, dmbziueaajmo}, {0, 0, 0, 0, NULL} };
static const uint8_t kxovvetfzpad[] = { 0x20, 0x0, 0x0, 0x00, 0x00};
static const srbjiaxreyht pbhzbtpsnpub[] = { {3, 0, 10, 0x20, kxovvetfzpad}, {0, 0, 0, 0, NULL} };
static const uint8_t yvzuvbtlttwe[] = { 0x50, 0x50, 0x50, 0x00, 0x40};
static const srbjiaxreyht xisjuykcoyqp[] = { {1, 1, 5, 0x70, yvzuvbtlttwe}, {0, 0, 0, 0, NULL} };
static const uint8_t wnfvuzdeiimr[] = {0x02, 0x04, 0x06, 0x08, 0x0a, 0x0c, 0x0e, 0x10, 0x11, 0x13, 0x14, 0x16, 0x18, 0x1a, 0x1b};
static const srbjiaxreyht srutlrqbdill[] = { {0, 0, 3, 0xfF, wnfvuzdeiimr}, {0, 0, 0, 0, NULL} };
static const uint8_t hllfohfmfoil[] = { 0x09, 0x09, 0x02, 0x09, 0x09};
static const srbjiaxreyht znkmqvqilzyr[] = { {1, 1, 10, 0x0F, hllfohfmfoil}, {0, 0, 0, 0, NULL} };
static const uint8_t amqakavjmqpd[] = {0xc0, 0xc0, 0xc0, 0x00, 0xc0};
static const srbjiaxreyht vwscklnffyeu[] = { {1, 0, 4, 0xC0, amqakavjmqpd}, {3, 0, 10, 0x07, ypyrmwtpomqr}, {0, 0, 0, 0, NULL} };
static const uint8_t bsgeijssfjwg[] = {6, 6, 6, 6, 6};
static const uint8_t xsqlrhmgxltc[] = {0, 2, 1, 0};
static const srbjiaxreyht usqyxwejuzcf[] = { {1, 0, 4, 0x0f, bsgeijssfjwg}, {2, 0, 4, 0x03, xsqlrhmgxltc}, {0, 0, 0, 0, NULL} };
static const uint8_t cztjpnnyqgsq[] = {0, 0xc0, 0x80, 0x40};
static const srbjiaxreyht yybzbksdpajd[] = { {2, 1, 2, 0xE0, cztjpnnyqgsq}, {0, 0, 0, 0, NULL} };
static const uint8_t bzqbhfkhzabk[] = {0, 0x20, 0x60, 0xA0};
static const srbjiaxreyht tvhwcvmsyyup[] = { {2, 0, 4, 0xE0, bzqbhfkhzabk}, {0, 0, 0, 0, NULL} };
static const uint8_t adepjrjmyflj[] = {0, 0, 0, 0, 4};
static const srbjiaxreyht hwexjkkeehcg[] = { {2, 0, 4, 0x04, adepjrjmyflj}, {0, 0, 0, 0, NULL} };
static const int8_t cplcynbrcjqi[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t rsayssmripvl[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t sqfkedbqwbse[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16,  20-16, 21-16, 21-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t imotugrgwtbl[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16};
static const int8_t jwlupoyiyfrk[] = { 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t rnjmuqvdldvq[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16};
static const int8_t cqjgriqothkw[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t wiirfgbndhwb[] = { 16-16, 16-16, 16-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16,  20-16, 21-16, 21-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t zcvrnunbsynt[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16};
static const int8_t mqkoibuqoqja[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t gkrympdgasfr[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16, 30-16};
static const int8_t xsbeifxlusda[] = { 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c};
static const int8_t ceidsyunkzfi[] = { 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t npjmkbkbssri[] = { 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t nreqwjygypgr[] = { 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16};
static const int8_t mtzhmwkrobqn[] = { 16-10, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 24-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t lfdcvdhalwdg[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t haukowtaggod[] = { 16-16, 16-16, 16-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16, 30-16};
static const int8_t aubhtiwhtzwi[] = { 16-16, 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 27-16, 28-16, 29-16, 30-16, 30-16, 30-16};
static const uint8_t tuxwbwdablhn[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t mzrfbnqakbsn[] = { 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t qgdcpmmavqox[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t nwtqorlanvey[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t awiacyajkfbv[] = { 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d};
static const uint8_t cotrrbqimult[] = { 0x60, 0x61, 0x62, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69, 0x70, 0x71, 0x72, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 0x80, 0x81, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88};
static const uint8_t bwetzuolkxmy[] = { 0, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t qgcolbxkirub[] = { 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20};
static const uint8_t xidchkgwawuc[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0};
static const uint8_t nmolzfmcdyct[] = { 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18};
static const uint8_t iwwcdvhhnhnw[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t bqzejbxcgxsg[] = { 0x3D, 0x3D, 0x3E, 0x3F, 0x40, 0x41, 0x42, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48, 0x49, 0x4A, 0x4B, 0x4C, 0x4D, 0x4E, 0x4F, 0x50, 0x51, 0x52, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58};
static const uint8_t nwkwcjmwpwir[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t pvsorfureror[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 1};
static const uint8_t wsfcxafcxreo[] = { 0X79, 0x7B, 0x7D, 0x7F, 0x81, 0x83, 0x85, 0x87, 0x89, 0x8B, 0x8D, 0x8F, 0x91, 0x93, 0x95, 0x97, 0x99, 0x9B, 0x9D, 0x9F, 0xA1, 0xA3, 0xA5, 0xA7, 0xA9, 0xAB, 0xAD, 0xAF, 0xB1};
static const uint8_t gqumcoaqmiex[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t bmffebrmzjrg[] = { 0x1c, 0x1d, 0x1e, 0x1f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18};
static const uint8_t yfjxvqyslrrg[] = { 0x01, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x05};
static const uint8_t uukvadplkoxd[] = { 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t xtxejffmuneb[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t ntdruvybdjdu[] = { 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0x0f};
static const uint8_t umtyimaxhaqh[] = { 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t drbggtjjncpr[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t htkixwbtswrg[] = { 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5};
static const uint8_t jjcpdseefqxq[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const struct wscodbmjbktx isxavciifnyk = { cplcynbrcjqi, { 0, 1, 0x40, 6, tuxwbwdablhn } };
static const struct wscodbmjbktx eftthwofcwcr = { rsayssmripvl, { 0, 3, 0x04, 2, mzrfbnqakbsn } };
static const struct wscodbmjbktx xoktxtcxkstd = { jwlupoyiyfrk, { 0, 1, 0x01, 0, nwtqorlanvey } };
static const struct wscodbmjbktx ylbzoubndlfv = { jwlupoyiyfrk, { 0, 2, 0x01, 0, nwtqorlanvey } };
static const struct wscodbmjbktx euxkwzlzuwaf = { imotugrgwtbl, { 1, 2, 0x01, 0, xidchkgwawuc } };
static const struct wscodbmjbktx hotyxxcmorep = { cplcynbrcjqi, { 0, 10, 0x01, 0, tuxwbwdablhn } };
static const struct wscodbmjbktx parpdhefvtab = { rsayssmripvl, { 0, 3, 0x1F, 0, awiacyajkfbv } };
static const struct wscodbmjbktx yppgniqoksfm = { cplcynbrcjqi, { 1, 3, 0xFF, 0, cotrrbqimult } };
static const struct wscodbmjbktx uaqqeyvvobhp = { rnjmuqvdldvq, { 0, 0, 0, 0, NULL } };
static const struct wscodbmjbktx gxwjutmejxvu = { sqfkedbqwbse, { 3, 6, 0x01, 0, qgdcpmmavqox } };
static const struct wscodbmjbktx gxanzhyuafjw = { cqjgriqothkw, { 0, 0, 0, 0, NULL } };
static const struct wscodbmjbktx dpcbraygfzzq = { jwlupoyiyfrk, { 1, 10, 0x01, 0, nwtqorlanvey } };
static const struct wscodbmjbktx xzgukzrwqvln = { sqfkedbqwbse, { 1, 6, 0x01, 0, qgdcpmmavqox } };
static const struct wscodbmjbktx dkmwaidgkket = { sqfkedbqwbse, { 2, 6, 0x01, 0, qgdcpmmavqox } };
static const struct wscodbmjbktx nbadiwmcydfa = { wiirfgbndhwb, { 0, 12, 0x04, 2, bwetzuolkxmy } };
static const struct wscodbmjbktx gtnfysdofxif = { jwlupoyiyfrk, { 1, 1, 0x04, 2, nwtqorlanvey } };
static const struct wscodbmjbktx kkcvhmnjrioa = { jwlupoyiyfrk, { 0, 10, 0x02, 1, nwtqorlanvey } };
static const struct wscodbmjbktx mqkmpsmdmiru = { zcvrnunbsynt, { 0, 8, 0x01, 0, nwtqorlanvey } };
static const struct wscodbmjbktx vhednltgggkl = { rsayssmripvl, { 0, 10, 0x3e, 1, qgcolbxkirub } };
static const struct wscodbmjbktx orenitlhzwnl = { jwlupoyiyfrk, { 0, 7, 0x01, 0, nwtqorlanvey } };
static const struct wscodbmjbktx znvsgukzefgj = { jwlupoyiyfrk, { 1, 0, 0x01, 0, nwtqorlanvey } };
static const struct wscodbmjbktx ksrayuarwjtj = { rsayssmripvl, { 0, 12, 0x1f, 0, nmolzfmcdyct } };
static const struct wscodbmjbktx somajjvmnyqn = { zcvrnunbsynt, { 0, 7, 0x01, 0, xidchkgwawuc } };
static const struct wscodbmjbktx eycioytqknsx = { mqkoibuqoqja, { 0, 0, 0, 0, NULL } };
static const struct wscodbmjbktx ppycqtphwnuz = { zcvrnunbsynt, { 0, 9, 0x01, 0, iwwcdvhhnhnw } };
static const struct wscodbmjbktx apvpceeiydcx = { jwlupoyiyfrk, { 0, 3, 0x01, 0, nwtqorlanvey } };
static const struct wscodbmjbktx syjbmjkopivb = { wiirfgbndhwb, { 0, 11, 0x7F, 0, bqzejbxcgxsg } };
static const struct wscodbmjbktx xlctxukfagla = { jwlupoyiyfrk, { 0, 0, 0x01, 0, nwtqorlanvey } };
static const struct wscodbmjbktx nydfxdilyimh = { zcvrnunbsynt, { 0, 2, 0x01, 0, iwwcdvhhnhnw } };
static const lieoifkbswcz nahvxqafzgop[2] = { { 0, 7, 0x04, 2, nwkwcjmwpwir }, { 0, 1, 0x01, 0, umtyimaxhaqh } };
static const struct wscodbmjbktx qxdzvqddehie = { zcvrnunbsynt, { 0x10, 0, 0, 2, (const uint8_t*)nahvxqafzgop } };
static const struct wscodbmjbktx sdjjmyazaobd = { sqfkedbqwbse, { 2, 2, 0x20, 5, qgdcpmmavqox } };
static const struct wscodbmjbktx snhznrtscwoh = { sqfkedbqwbse, { 2, 3, 0x80, 7, qgdcpmmavqox } };
static const struct wscodbmjbktx yqpnditmwonr = { gkrympdgasfr, { 1, 12, 0x01, 0, pvsorfureror } };
static const struct wscodbmjbktx fgteclqwvypk = { cplcynbrcjqi, { 1, 4, 0x01, 0, tuxwbwdablhn } };
static const struct wscodbmjbktx sybcvgmdylst = { wiirfgbndhwb, { 0, 11, 0xff, 0, wsfcxafcxreo } };
static const struct wscodbmjbktx dlqgxetzemki = { xsbeifxlusda, { 2, 3, 0x80, 7, gqumcoaqmiex } };
static const struct wscodbmjbktx vonnpwtehkpp = { rsayssmripvl, { 0, 12, 0x1f, 0, bmffebrmzjrg } };
static const struct wscodbmjbktx zzpndcuiqygi = { wiirfgbndhwb, { 1, 12, 0x04, 2, bwetzuolkxmy } };
static const struct wscodbmjbktx qpwvppcoajoo = { ceidsyunkzfi, { 1, 2, 0xf0, 4, yfjxvqyslrrg } };
static const struct wscodbmjbktx vmsyeoerpcbo = { zcvrnunbsynt, { 0, 7, 0x10, 4, iwwcdvhhnhnw } };
static const struct wscodbmjbktx rrqwtapoxwws = { zcvrnunbsynt, { 0, 0, 0, 0, NULL } };
static const struct wscodbmjbktx hpyguqhasgog = { npjmkbkbssri, { 0, 0, 0, 0, NULL } };
static const struct wscodbmjbktx qwctzlqurxdy = { nreqwjygypgr, { 1, 5, 0x01, 0, uukvadplkoxd } };
static const struct wscodbmjbktx tkrayuuyqcxh = { wiirfgbndhwb, { 0, 9, 0x40, 6, bwetzuolkxmy } };
static const struct wscodbmjbktx gsrnsfjloqer = { zcvrnunbsynt, { 1, 0, 0x01, 0, iwwcdvhhnhnw } };
static const struct wscodbmjbktx iavlxfeyybjd = { nreqwjygypgr, { 1, 7, 0x10, 4, uukvadplkoxd } };
static const struct wscodbmjbktx flrccffprjxa = { rsayssmripvl, { 0, 0, 0, 0, NULL } };
static const struct wscodbmjbktx zeshamptsbtz = { mtzhmwkrobqn, { 0, 0, 0, 0, NULL } };
static const struct wscodbmjbktx obdyrantbdfg = { ceidsyunkzfi, { 0, 0, 0, 0, NULL } };
static const struct wscodbmjbktx kxlehxjhafxr = { zcvrnunbsynt, { 3, 3, 0x01, 0, iwwcdvhhnhnw } };
static const struct wscodbmjbktx xdcmbuypvmwr = { lfdcvdhalwdg, { 0, 4, 0x01, 0, xtxejffmuneb } };
static const struct wscodbmjbktx sjktkrmdodrd = { rsayssmripvl, { 0, 5, 0x0f, 0, ntdruvybdjdu } };
static const struct wscodbmjbktx dzwyylvjtzmk = { jwlupoyiyfrk, { 0, 3, 0x01, 0, iwwcdvhhnhnw } };
static const struct wscodbmjbktx iypacpobzjuo = { jwlupoyiyfrk, { 1, 3, 0x01, 0, xidchkgwawuc } };
static const struct wscodbmjbktx lyldgksdaetb = { haukowtaggod, { 0, 0, 0, 0, NULL } };
static const struct wscodbmjbktx zjslofaamxyp = { zcvrnunbsynt, { 0, 13, 0x01, 0, xidchkgwawuc } };
static const struct wscodbmjbktx bkzbnevwnggk = { imotugrgwtbl, { 0, 0, 0x01, 0, xidchkgwawuc } };
static const struct wscodbmjbktx zbneyfdgjmgd = { zcvrnunbsynt, { 0, 1, 0x01, 0, iwwcdvhhnhnw } };
static const struct wscodbmjbktx kpmkxpudvpbo = { jwlupoyiyfrk, { 1, 1, 0x10, 4, nwtqorlanvey } };
static const struct wscodbmjbktx fwvzshasvmyo = { imotugrgwtbl, { 0, 3, 0x01, 0, xidchkgwawuc } };
static const struct wscodbmjbktx gxrgmhwlrkhg = { imotugrgwtbl, { 0, 2, 0x08, 3, xidchkgwawuc } };
static const struct wscodbmjbktx ymzofyqomcwt = { wiirfgbndhwb, { 2, 3, 0x80, 7, bwetzuolkxmy } };
static const lieoifkbswcz hbjpzxxohonm[2] = { { 0, 4, 0x80, 7, nwkwcjmwpwir }, { 0, 5, 0x01, 0, umtyimaxhaqh } };
static const struct wscodbmjbktx xdyyxheudbee = { zcvrnunbsynt, { 0x10, 0, 0, 2, (const uint8_t*)hbjpzxxohonm } };
static const struct wscodbmjbktx xiwmtfzsqzfw = { imotugrgwtbl, { 0, 3, 0x04, 2, xidchkgwawuc } };
static const struct wscodbmjbktx kawiuujoybwz = { imotugrgwtbl, { 0, 1, 0x01, 0, xidchkgwawuc } };
static const lieoifkbswcz ytuuvylzziku[2] = { { 0, 2, 0x08, 3, drbggtjjncpr }, { 0, 2, 0x10, 4, iwwcdvhhnhnw } };
static const struct wscodbmjbktx xaqmghgmbkpb = { zcvrnunbsynt, { 0x10, 0, 0, 2, (const uint8_t*)ytuuvylzziku } };
static const lieoifkbswcz sakvoxkuzsst[2] = { { 1, 0, 0x0F, 0, htkixwbtswrg }, { 1, 0, 0x10, 4, xidchkgwawuc } };
static const struct wscodbmjbktx msmrusgxkqtj = { imotugrgwtbl, { 0x10, 0, 0, 2, (const uint8_t*)sakvoxkuzsst } };
static const struct wscodbmjbktx hblgrlgpyoet = { imotugrgwtbl, { 1, 1, 0x01, 0, xidchkgwawuc } };
static const struct wscodbmjbktx njduflecdoqp = { zcvrnunbsynt, { 0, 1, 0x08, 3, umtyimaxhaqh } };
static const struct wscodbmjbktx auaewvylxkez = { sqfkedbqwbse, { 3, 6, 0x02, 1, qgdcpmmavqox } };
static const struct wscodbmjbktx bnqhrpudkhrd = { jwlupoyiyfrk, { 3, 6, 0x01, 0, nwtqorlanvey } };
static const struct wscodbmjbktx dovydskcoyph = { aubhtiwhtzwi, { 0, 3, 0x04, 2, jjcpdseefqxq } };
static const struct wscodbmjbktx ghgjjuztaesj = { cplcynbrcjqi, { 0, 0, 0, 0, NULL } };
static const struct pktfcxxfncig scpicsspoord = { 0x00, 1, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct pktfcxxfncig thorhcukfpln = { 0x11, 0, -3, 2, {0, 1, 0, 0}, 1, -1, 0, 0 };
static const struct pktfcxxfncig vkmtbmjmvjop = { 0x22, 1, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct pktfcxxfncig rgphprgzgcbh = { 0x33, 0, -3, 2, {0, 1, 0, 0}, 3, -1, 0, 0 };
static const struct pktfcxxfncig ywgpfqyyxxph = { 0x00, 0, -3, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct pktfcxxfncig ffisczxrscmb = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 1, 0xff };
static const struct pktfcxxfncig zuvszjqpjpif = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 1, 0xff };
static const struct pktfcxxfncig hidgeduttqfu = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct pktfcxxfncig ngrzeysnitls = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 0, 0x0 };
static const struct pktfcxxfncig jeykmogorxgj = { 0x22, 0, -1, 1, {0, 0, 0, 0}, 2, 0, 0, 0x0 };
static const struct pktfcxxfncig idcjiyplxduq = { 0x33, 0, -1, 1, {0, 0, 0, 0}, 3, 0, 0, 0x0 };
static const struct pktfcxxfncig epwtgzhkdnxx = { 0x00, 0, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct pktfcxxfncig euycpbrasfyv = { 0x11, 0, -1, 2, {1, 0, 0, 1}, 1, 1, 0xff, 0xff };
static const struct pktfcxxfncig qslctipbfazs = { 0x22, 0, -1, 2, {1, 0, 0, 1}, 2, 1, 0xff, 0xff };
static const struct pktfcxxfncig eshpbeukhocu = { 0x00, 0, -2, 4, {1, 0, 0, 1}, 0, 2, 0xff, 0xff };
static const struct pktfcxxfncig sbdfzeccmaqu = { 0x00, 1, -2, 4, {1, 0, 0, 1}, 0, 2, 0xff, 0xff };
static const struct pktfcxxfncig hlokiuxcntir = { 0x00, 0, -1, 2, {0, 0, 0, 1}, 0, 1, 0xff, 0 };
static const struct pktfcxxfncig tbefjzytputb = { 0x22, 0, -1, 2, {0, 0, 0, 1}, 2, 1, 0xff, 0 };
static const struct pktfcxxfncig sutoxatvacfq = { 0x00, 0, -1, 1, {1, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct pktfcxxfncig gezhqrxwpcvj = { 0x11, 0, -1, 1, {1, 0, 0, 0}, 1, 0, 0, 0x0 };
static const struct pktfcxxfncig tinvjsjlztyy = { 0x22, 0, -1, 1, {1, 0, 0, 0}, 2, 0, 0, 0x0 };
static const struct pktfcxxfncig vmmofgybaymv = { 0x00, 0, 0, 1, {0, 0, 0, 1}, 1, 0, 0xff, 0 };
static const struct pktfcxxfncig kdmwvfqfqpll = { 0x11, 0, 0, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct pktfcxxfncig smwragrlwavl = { 0x22, 0, 0, 1, {0, 0, 0, 1}, 3, 0, 0xff, 0 };
static const struct pktfcxxfncig oxxsqsispxia = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0x0 };
static const struct pktfcxxfncig sdjplhlnxhzg = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0xf8 };
static const struct pktfcxxfncig sygjnpzqzwmc = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0xf2 };
static const struct pktfcxxfncig immjrkfcobrf = { 0x11, 0, -2, 1, {0, 0, 1, 0}, 1, 0, 0, 0x0 };
static const struct pktfcxxfncig sofoqdtfequm = { 0x00, 1, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct pktfcxxfncig zktfbbqrcufi = { 0, 0, 0xff, 0, {6, 0, 0, 0}, 0, 3, 0, 0xff };
static const struct pktfcxxfncig xpwamxtikdbb = { 0, 0, 0xff, 0, {6, 0, 0, 0}, 0, 4, 0, 0xff };
static const struct pktfcxxfncig zzzejwheubuv = { 0, 0, 0xff, 0, {0, 0, 0, 0}, 0, 4, 0, 0xff };
static const struct pktfcxxfncig dxobunvidkts = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x0 };
static const struct pktfcxxfncig tywwqmoetbpr = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x02 };
static const struct pktfcxxfncig rlxfdkgxbhaw = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x0 };
static const struct pktfcxxfncig cxtlgictapbi = { 0x00, 3, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct pktfcxxfncig qfaeuxxkbolu = { 0x11, 3, -1, 2, {1, 0, 0, 1}, 1, 1, 0xff, 0xff };
static const struct pktfcxxfncig furxlgqvmvle = { 0x22, 3, -1, 2, {1, 0, 0, 1}, 2, 1, 0xff, 0xff };
static const struct pktfcxxfncig niabfktfoptq = { 0x00, 1, 0, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct pktfcxxfncig yydxualqtuaa = { 0x00, 0, 0, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct pktfcxxfncig rmwjeiydhtdi = { 0x00, 0, 0, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct pktfcxxfncig edekzrzzumla = { 0x11, 0, 0, 1, {0, 0, 0, 1}, 3, 0, 0xff, 0 };
static const struct pktfcxxfncig sviydcyvzsbo = { 0x11, 0, 0, 1, {1, 0, 0, 1}, 2, 0, 0xff, 0xff };
static const struct pktfcxxfncig txantqrqulcf = { 0x00, 5, -10, 1, {0, 0, 1, 0}, 0, -4, 0, 0x0 };
static const struct pktfcxxfncig wjlxeymsdhib = { 0x00, 5, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0x0 };
static const struct pktfcxxfncig fmiautdpefoh = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 6, 0x0 };
static const struct pktfcxxfncig juiwgoflmtxn = { 0x00, 0, -1, 1, {6, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct pktfcxxfncig lrhujomivxhq = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 3 };
static const struct pktfcxxfncig hfzogtvctnrv = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0xfe };
static const struct pktfcxxfncig iweybqhgkwwg = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x08 };
static const struct pktfcxxfncig avbwnhjdvsmf = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x88 };
static const struct pktfcxxfncig exfjaoarjmrf = { 2, 0, 0x0f, 0, {0, 0, 0, 0}, 0, 3, 0, 0x0f };
static const struct pktfcxxfncig ygqcwdbtvteb = { 0x00, 0, -1, 1, {10, 0, 0, 0}, 0, 0, 0, 0 };
static const struct pktfcxxfncig dvrtlkxjsbko = { 0x00, 0, -3, 1, {0, 0, 0, 1}, 1, 4, 0xff, 0 };
static const struct pktfcxxfncig waaqmzabdnvg = { 0x11, 8, -9, 1, {0, 0, 0, 1}, 2, -2, 0xff, 0 };
static const struct pktfcxxfncig xdfvtxjlofne = { 0x11, 0, -13, 2, {0, 1, 0, 0}, 1, -11, 0, 0 };
static const struct pktfcxxfncig djirubnnnhqd = { 0x11, 9, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct pktfcxxfncig khdcvbqlltdl = { 0x22, 0, -13, 2, {0, 1, 0, 0}, 2, -11, 0, 0 };
static const struct pktfcxxfncig ewprzbjmjkrd = { 0x00, 0, 0, 1, {0, 0, 0, 0}, 1, -1, 0, 0 };
static const struct pktfcxxfncig ypfvebqdpgrc = { 0x00, 4, -1, 1, {1, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct pktfcxxfncig ckyrghbictlq = { 0x00, 0, -1, 1, {12, 0, 0, 0}, 0, 0, 11, 0x0 };
static const struct pktfcxxfncig xrzgzpnnyfot = { 0x00, 0, -1, 1, {13, 0, 0, 0}, 0, 0, 4, 2 };
static const struct pktfcxxfncig qqourdnwlkvk = { 0x00, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 0, 0x0 };
static const struct pktfcxxfncig woxhlypkiojh = { 0x22, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 0, 0x0 };
static const struct pktfcxxfncig wqpsuqujbegn = { 0x11, 1, 0, 1, {13, 1, 0, 0}, 1, -5, 1, 0xFF };
static const struct pktfcxxfncig lscnzubucfmn = { 0x33, 1, 0, 1, {13, 1, 0, 0}, 3, -5, 1, 0xFF };
static const struct pktfcxxfncig sramwdyhkxpb = { 0x00, 0, -1, 1, {6, 0, 0, 0}, -1, 0, 0, 0x7f };
static const struct pktfcxxfncig esrfeyaukrkr = { 0x00, 0xff, 0, 1, {0, 1, 0, 0}, 0, 0, 1, 0x2c };
static const struct pktfcxxfncig mkljzrajkcxc = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 1, 0xaa };
static const struct pktfcxxfncig accjttodiulg = { 0x11, 1, 0, 1, {1, 0, 0, 1}, 0, 0, 0xff, 0xff };
static const struct pktfcxxfncig kbaewdibwotz = { 0, 0, 3, 0, {0, 0, 0, 0}, 0, 0, 0, 0 };
static const struct pktfcxxfncig zmsfwvstmpzu = { 0, 0, 8, 0, {0, 0, 0, 0}, 0, 0, 0, 0 };
static const struct pktfcxxfncig xpkuuvbfprrg = { 0x00, 0, -5, 1, {14, 0, 0, 0}, 1, -5, 0, 0xfc };
static const struct pktfcxxfncig tupcabtzlxtu = { 0x00, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 4, 7 };
static const struct pktfcxxfncig soaylxabbvcp = { 0x00, 0xff, -1, 1, {0, 1, 0, 0}, 1, 0, 1, 0x80 };
static const struct pktfcxxfncig xnjxjpmsbrwq = { 0x00, 0, -1, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct pktfcxxfncig ouopuszxsrbb = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 0, 0x09 };
static const struct pktfcxxfncig dxktsvpsiveo = { 0x22, 0, -1, 1, {0, 0, 0, 0}, 2, 0, 0, 0xF1 };
static const struct pktfcxxfncig lldlvrazjdws = { 0x11, 0, 0, 1, {0, 0, 0, 0}, 0, -1, 0, 0 };
static const struct pktfcxxfncig vtmpirjbpzyr = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x54 };
static const struct pktfcxxfncig ukqovkdbujkv = { 0x11, 0, 0, 1, {15, 0, 0, 0}, -1, 0, 0, 0 };
static const struct pktfcxxfncig asjlcfmntoqd = { 0x00, 0, 0, 1, {0, 1, 0, 0}, 2, 0, 15, 0x0 };
static const struct pktfcxxfncig tlkbozzdilei = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0xed };
static const struct pktfcxxfncig qauwuvtpflxi = { 0x00, 0, -1, 1, {1, 0, 0, 0}, 1, 0, 0, 0x14 };
static const struct tbacqdqyhzjl neblmufxjobh[] = { { egdktbtdutis,	&ywgpfqyyxxph }, { vazisqcodoyh,	&scpicsspoord }, { vazisqcodoyh,	&thorhcukfpln }, { vazisqcodoyh,	&vkmtbmjmvjop }, { vazisqcodoyh,	&rgphprgzgcbh }, {NULL, NULL} };
static const struct tbacqdqyhzjl iomtqjccekux[] = { { vazisqcodoyh,	&scpicsspoord }, { vazisqcodoyh,	&thorhcukfpln }, { vazisqcodoyh,	&vkmtbmjmvjop }, { vazisqcodoyh,	&rgphprgzgcbh }, {NULL, NULL} };
static const struct tbacqdqyhzjl vvivsaqmctsn[] = { { vazisqcodoyh,	&scpicsspoord }, { vazisqcodoyh,	&thorhcukfpln }, {NULL, NULL} };
static const struct tbacqdqyhzjl cxxqpwnfospn[] = { { egdktbtdutis,	&ffisczxrscmb }, {NULL, NULL} };
static const struct tbacqdqyhzjl ybjlgbokpeap[] = { { vazisqcodoyh,	&ffisczxrscmb }, {NULL, NULL} };
static const struct tbacqdqyhzjl rlwfjarwbyva[] = { { egdktbtdutis,	&hidgeduttqfu }, {NULL, NULL} };
static const struct tbacqdqyhzjl vixgnerqasdw[] = { { egdktbtdutis,	&hidgeduttqfu }, { egdktbtdutis,	&ngrzeysnitls }, {NULL, NULL} };
static const struct tbacqdqyhzjl tqokiavwcgfc[] = { { egdktbtdutis,	&ngrzeysnitls }, { egdktbtdutis,	&jeykmogorxgj }, { egdktbtdutis,	&idcjiyplxduq }, {NULL, NULL} };
static const struct tbacqdqyhzjl gcpbulrrerdq[] = { {NULL, NULL} };
static const struct tbacqdqyhzjl fwastflmujzt[] = { { egdktbtdutis, &sutoxatvacfq}, { egdktbtdutis, &vmmofgybaymv}, {NULL, NULL} };
static const struct tbacqdqyhzjl trsclbhfsdgr[] = { { vazisqcodoyh,	&oxxsqsispxia }, {NULL, NULL} };
static const struct tbacqdqyhzjl ewcwtwtnjumd[] = { { vazisqcodoyh,	&immjrkfcobrf }, {NULL, NULL} };
static const struct tbacqdqyhzjl furfqjhejfgv[] = { { egdktbtdutis, &epwtgzhkdnxx }, { egdktbtdutis, &vmmofgybaymv}, {NULL, NULL} };
static const struct tbacqdqyhzjl fqdumxtpfoqx[] = { { egdktbtdutis,	&tlkbozzdilei }, { egdktbtdutis,	&ngrzeysnitls }, {NULL, NULL} };
static const struct tbacqdqyhzjl vjmyvdqynrdc[] = { { egdktbtdutis, &epwtgzhkdnxx }, {NULL, NULL} };
static const struct tbacqdqyhzjl olhrfncspuea[] = { { lccydooawqqq,	&hidgeduttqfu }, {NULL, NULL} };
static const struct tbacqdqyhzjl tmzqoiuybvgp[] = { { lccydooawqqq,	&hidgeduttqfu }, { lccydooawqqq,	&ngrzeysnitls }, {NULL, NULL} };
static const struct tbacqdqyhzjl twbcxiqkpyzk[] = { { vazisqcodoyh,	&oxxsqsispxia }, { egdktbtdutis, &vmmofgybaymv}, {NULL, NULL} };
static const struct tbacqdqyhzjl mbtdrqfkrhlf[] = { { egdktbtdutis, &hlokiuxcntir}, { egdktbtdutis, &tbefjzytputb}, { egdktbtdutis, &vmmofgybaymv}, { egdktbtdutis, &smwragrlwavl}, {NULL, NULL} };
static const struct tbacqdqyhzjl rhpoedahrstb[] = { { egdktbtdutis, &sutoxatvacfq}, {NULL, NULL} };
static const struct tbacqdqyhzjl bhkyctzmvica[] = { { egdktbtdutis, &epwtgzhkdnxx}, { egdktbtdutis, &vmmofgybaymv}, { egdktbtdutis, &jeykmogorxgj}, {NULL, NULL} };
static const struct tbacqdqyhzjl amkaibhhhfsc[] = { { egdktbtdutis, &epwtgzhkdnxx}, { egdktbtdutis, &vmmofgybaymv}, {NULL, NULL} };
static const struct tbacqdqyhzjl ebahprebnmen[] = { { egdktbtdutis, &sofoqdtfequm}, {NULL, NULL} };
static const struct tbacqdqyhzjl uttppbcvqthg[] = { { vazisqcodoyh,	&oxxsqsispxia }, { egdktbtdutis, &vmmofgybaymv}, {NULL, NULL} };
static const struct tbacqdqyhzjl fqgiigpemcaz[] = { { egdktbtdutis, &vmmofgybaymv}, {NULL, NULL} };
static const struct tbacqdqyhzjl byrdqdaczwxz[] = { { lccydooawqqq,	&ffisczxrscmb }, {NULL, NULL} };
static const struct tbacqdqyhzjl yidkopkslqak[] = { { rxcxbbegyxhy,	&zktfbbqrcufi }, { egdktbtdutis,	&hidgeduttqfu }, {NULL, NULL} };
static const struct tbacqdqyhzjl rktudivhsjgb[] = { { rxcxbbegyxhy,	&xpwamxtikdbb }, { egdktbtdutis,	&hidgeduttqfu }, {NULL, NULL} };
static const struct tbacqdqyhzjl dlpifexbyqlw[] = { { rxcxbbegyxhy,	&zzzejwheubuv }, { egdktbtdutis,	&hidgeduttqfu }, {NULL, NULL} };
static const struct tbacqdqyhzjl dsuxtremdabv[] = { { egdktbtdutis, &yydxualqtuaa}, {NULL, NULL} };
static const struct tbacqdqyhzjl vqivsbeaooll[] = { { vazisqcodoyh,	&sdjplhlnxhzg }, {NULL, NULL} };
static const struct tbacqdqyhzjl iprctvkigumk[] = { { vazisqcodoyh,	&sygjnpzqzwmc }, {NULL, NULL} };
static const struct tbacqdqyhzjl rjvlmqcbgtfl[] = { { vazisqcodoyh,	&dxobunvidkts }, {NULL, NULL} };
static const struct tbacqdqyhzjl wotxnpmxljzj[] = { { vazisqcodoyh,	&tywwqmoetbpr }, {NULL, NULL} };
static const struct tbacqdqyhzjl dvlmbpsinqoo[] = { { egdktbtdutis,	&gezhqrxwpcvj }, { egdktbtdutis,	&tinvjsjlztyy }, {NULL, NULL} };
static const struct tbacqdqyhzjl dyoerhuugkim[] = { { egdktbtdutis,	&ngrzeysnitls }, {NULL, NULL} };
static const struct tbacqdqyhzjl lrwothecqnqk[] = { { egdktbtdutis, &gezhqrxwpcvj}, {NULL, NULL} };
static const struct tbacqdqyhzjl wiuiioibmfwg[] = { { egdktbtdutis, &euycpbrasfyv}, {NULL, NULL} };
static const struct tbacqdqyhzjl wleslucdzswj[] = { { egdktbtdutis, &rlxfdkgxbhaw}, {NULL, NULL} };
static const struct tbacqdqyhzjl ikrgztxhbhme[] = { { egdktbtdutis, &cxtlgictapbi}, { egdktbtdutis, &qfaeuxxkbolu}, { egdktbtdutis, &furxlgqvmvle}, {NULL, NULL} };
static const struct tbacqdqyhzjl dikotbgrtiuo[] = { { lccydooawqqq, &xpkuuvbfprrg}, { lccydooawqqq, &niabfktfoptq}, { egdktbtdutis, &rmwjeiydhtdi}, {NULL, NULL} };
static const struct tbacqdqyhzjl wkhvrdgxemas[] = { { egdktbtdutis,	&hidgeduttqfu }, { egdktbtdutis, &vmmofgybaymv}, {NULL, NULL} };
static const struct tbacqdqyhzjl tghubrggbsnn[] = { { egdktbtdutis, &sviydcyvzsbo}, {NULL, NULL} };
static const struct tbacqdqyhzjl pwvdqwkpzxsd[] = { { lccydooawqqq,	&txantqrqulcf }, { lccydooawqqq,	&wjlxeymsdhib }, {NULL, NULL} };
static const struct tbacqdqyhzjl qjwvrgtjudlw[] = { { egdktbtdutis, &hlokiuxcntir}, { egdktbtdutis, &vmmofgybaymv}, { egdktbtdutis, &kdmwvfqfqpll}, {NULL, NULL} };
static const struct tbacqdqyhzjl tynaglfwcjtt[] = { { lccydooawqqq,	&wjlxeymsdhib }, {NULL, NULL} };
static const struct tbacqdqyhzjl yfkkffuyjdjc[] = { { egdktbtdutis, &fmiautdpefoh}, {NULL, NULL} };
static const struct tbacqdqyhzjl pxkacdstmejh[] = { { egdktbtdutis, &juiwgoflmtxn}, {NULL, NULL} };
static const struct tbacqdqyhzjl tfqcvjqqgksc[] = { { egdktbtdutis, &euycpbrasfyv }, {NULL, NULL} };
static const struct tbacqdqyhzjl fxfxqyeahtnk[] = { { egdktbtdutis, &zuvszjqpjpif }, {NULL, NULL} };
static const struct tbacqdqyhzjl yzwkptrlibny[] = { { egdktbtdutis, &lrhujomivxhq }, {NULL, NULL} };
static const struct tbacqdqyhzjl najmcimiaeia[] = { { egdktbtdutis, &avbwnhjdvsmf }, {NULL, NULL} };
static const struct tbacqdqyhzjl bspfpjedoqeg[] = { { egdktbtdutis, &ngrzeysnitls }, { egdktbtdutis, &jeykmogorxgj }, {NULL, NULL} };
static const struct tbacqdqyhzjl piayrwdcoabm[] = { { lccydooawqqq, &hfzogtvctnrv }, {NULL, NULL} };
static const struct tbacqdqyhzjl pjyjlubiskul[] = { { rxcxbbegyxhy,	&exfjaoarjmrf }, { egdktbtdutis, &yydxualqtuaa}, { egdktbtdutis, &rmwjeiydhtdi}, {NULL, NULL} };
static const struct tbacqdqyhzjl butuufvlfofh[] = { { lccydooawqqq, &iweybqhgkwwg }, {NULL, NULL} };
static const struct tbacqdqyhzjl engafuusnyoi[] = { { rxcxbbegyxhy,	&exfjaoarjmrf }, {NULL, NULL} };
static const struct tbacqdqyhzjl azjugvbsdsqp[] = { { vazisqcodoyh,	&immjrkfcobrf }, { egdktbtdutis, &rmwjeiydhtdi}, { egdktbtdutis, &edekzrzzumla}, {NULL, NULL} };
static const struct tbacqdqyhzjl romdggzovziq[] = { { egdktbtdutis,	&ffisczxrscmb }, { egdktbtdutis, &vmmofgybaymv}, {NULL, NULL} };
static const struct tbacqdqyhzjl lenaojpypmgf[] = { { egdktbtdutis,	&ygqcwdbtvteb }, {NULL, NULL} };
static const struct tbacqdqyhzjl ygcxahquzvij[] = { { egdktbtdutis, &rmwjeiydhtdi}, { egdktbtdutis, &edekzrzzumla}, {NULL, NULL} };
static const struct tbacqdqyhzjl puyhqnzygnrs[] = { { egdktbtdutis, &epwtgzhkdnxx}, { egdktbtdutis, &vmmofgybaymv}, {egdktbtdutis, &qslctipbfazs}, {NULL, NULL} };
static const struct tbacqdqyhzjl cfwgnoydaeun[] = { { vazisqcodoyh, &hidgeduttqfu }, {NULL, NULL} };
static const struct tbacqdqyhzjl fmqkqpymqyvi[] = { { egdktbtdutis, &eshpbeukhocu}, { egdktbtdutis, &sbdfzeccmaqu}, {NULL, NULL} };
static const struct tbacqdqyhzjl nfuqjxctiyow[] = { { egdktbtdutis,	&dvrtlkxjsbko }, { vazisqcodoyh,	&scpicsspoord }, { vazisqcodoyh,	&xdfvtxjlofne }, { vazisqcodoyh,	&djirubnnnhqd }, { vazisqcodoyh,	&khdcvbqlltdl }, {NULL, NULL} };
static const struct tbacqdqyhzjl stucxxyamdmv[] = { { eqthmplkqpmk, &ewprzbjmjkrd}, {NULL, NULL} };
static const struct tbacqdqyhzjl auqvzdazqbtj[] = { { egdktbtdutis, &ewprzbjmjkrd}, {NULL, NULL} };
static const struct tbacqdqyhzjl xqxlikpvrrsq[] = { { egdktbtdutis, &ypfvebqdpgrc}, { egdktbtdutis, &vmmofgybaymv}, { egdktbtdutis, &smwragrlwavl}, {NULL, NULL} };
static const struct tbacqdqyhzjl aduwdhgzncqz[] = { { egdktbtdutis, &ckyrghbictlq}, { egdktbtdutis, &yydxualqtuaa}, {NULL, NULL} };
static const struct tbacqdqyhzjl qoxwndjnfccy[] = { { egdktbtdutis, &qqourdnwlkvk}, { egdktbtdutis, &wqpsuqujbegn}, { egdktbtdutis, &woxhlypkiojh}, { egdktbtdutis, &lscnzubucfmn}, {NULL, NULL} };
static const struct tbacqdqyhzjl lxeqknsnwmvy[] = { { egdktbtdutis, &qqourdnwlkvk}, { egdktbtdutis, &wqpsuqujbegn}, { egdktbtdutis, &qqourdnwlkvk}, { egdktbtdutis, &lscnzubucfmn}, {NULL, NULL} };
static const struct tbacqdqyhzjl bcvrjesyhbss[] = { { egdktbtdutis, &qqourdnwlkvk}, { egdktbtdutis, &wqpsuqujbegn}, {NULL, NULL} };
static const struct tbacqdqyhzjl qllnjqsepdux[] = { { egdktbtdutis, &sramwdyhkxpb}, { egdktbtdutis, &esrfeyaukrkr}, {NULL, NULL} };
static const struct tbacqdqyhzjl lmkxtcrveiui[] = { { egdktbtdutis, &mkljzrajkcxc}, {NULL, NULL} };
static const struct tbacqdqyhzjl zvwjvnoedyko[] = { { lccydooawqqq, &sutoxatvacfq}, {NULL, NULL} };
static const struct tbacqdqyhzjl xbqqeploqxoa[] = { { egdktbtdutis, &accjttodiulg}, { egdktbtdutis, &rmwjeiydhtdi}, {NULL, NULL} };
static const struct tbacqdqyhzjl lgosiqlfwtjf[] = { { egdktbtdutis,	&hidgeduttqfu }, { egdktbtdutis,	&yydxualqtuaa }, { egdktbtdutis,	&rmwjeiydhtdi }, {NULL, NULL} };
static const struct tbacqdqyhzjl irmhhvnxqwbx[] = { { vazisqcodoyh, &sutoxatvacfq}, {NULL, NULL} };
static const struct tbacqdqyhzjl snczkqcpgjfu[] = { { egdktbtdutis, &euycpbrasfyv }, { egdktbtdutis, &kdmwvfqfqpll}, {NULL, NULL} };
static const struct tbacqdqyhzjl mjrcpzynekqf[] = { { bodjhjgyoxhi, &kbaewdibwotz}, {NULL, NULL} };
static const struct tbacqdqyhzjl lijheqifumjh[] = { { bodjhjgyoxhi, &zmsfwvstmpzu}, {NULL, NULL} };
static const struct tbacqdqyhzjl hzekdkbdrpvm[] = { { vazisqcodoyh, &euycpbrasfyv}, { egdktbtdutis, &edekzrzzumla}, { NULL, NULL} };
static const struct tbacqdqyhzjl ydnuhcvrirma[] = { { egdktbtdutis, &vmmofgybaymv}, { egdktbtdutis, &kdmwvfqfqpll}, {NULL, NULL} };
static const struct tbacqdqyhzjl jhhgzesmesgc[] = { { egdktbtdutis, &tupcabtzlxtu}, { egdktbtdutis, &soaylxabbvcp}, {NULL, NULL} };
static const struct tbacqdqyhzjl ukusubqnfddc[] = { { lccydooawqqq, &sutoxatvacfq}, { egdktbtdutis, &vmmofgybaymv}, { egdktbtdutis, &kdmwvfqfqpll}, {NULL, NULL} };
static const struct tbacqdqyhzjl snxzripxaitf[] = { { egdktbtdutis,	&hidgeduttqfu }, { egdktbtdutis,	&xnjxjpmsbrwq }, { egdktbtdutis,	&ouopuszxsrbb }, { egdktbtdutis,	&rmwjeiydhtdi }, {NULL, NULL} };
static const struct tbacqdqyhzjl rruxbybbhcov[] = { { egdktbtdutis, &epwtgzhkdnxx}, { vazisqcodoyh, &euycpbrasfyv}, { egdktbtdutis, &rmwjeiydhtdi}, { egdktbtdutis, &edekzrzzumla}, {NULL, NULL} };
static const struct tbacqdqyhzjl bkdtbokwxvif[] = { { vazisqcodoyh, &euycpbrasfyv}, {NULL, NULL} };
static const struct tbacqdqyhzjl qyqoaflwwyom[] = { { egdktbtdutis, &ngrzeysnitls }, { egdktbtdutis, &dxktsvpsiveo }, {NULL, NULL} };
static const struct tbacqdqyhzjl ycpdjrrnteir[] = { { lccydooawqqq, &lldlvrazjdws}, {NULL, NULL} };
static const struct tbacqdqyhzjl etzpkrbcxmgi[] = { { egdktbtdutis,	&waaqmzabdnvg }, { egdktbtdutis,	&ngrzeysnitls }, { egdktbtdutis,   &jeykmogorxgj }, {NULL, NULL} };
static const struct tbacqdqyhzjl aszgewaorkyw[] = { { egdktbtdutis, &vtmpirjbpzyr}, {NULL, NULL} };
static const struct tbacqdqyhzjl falpnhpaffep[] = { { lccydooawqqq, &juiwgoflmtxn}, { vazisqcodoyh, &zuvszjqpjpif}, {NULL, NULL} };
static const struct tbacqdqyhzjl otmsnntvfxwn[] = { { egdktbtdutis, &xrzgzpnnyfot}, {NULL, NULL} };
static const struct tbacqdqyhzjl kuyrhcxxyktb[] = { { vazisqcodoyh, &zuvszjqpjpif}, {NULL, NULL} };
static const struct tbacqdqyhzjl tckarflpcrau[] = { { egdktbtdutis,	&ukqovkdbujkv }, { egdktbtdutis,	&asjlcfmntoqd }, {NULL, NULL} };
static const struct tbacqdqyhzjl tcdmydkfkcqe[] = { { egdktbtdutis,	&hidgeduttqfu }, { egdktbtdutis,	&qauwuvtpflxi }, {NULL, NULL} };
static const char* PREDEFINDED_NAMES[] = { "M96b (XIAOMI/TCL)", "M100b (SHINCO/SAMSUNG/ELECTROLUX)", "T102b (WHIRLPOOL/BOSCH/AIRWELL)", "M128b (FUJITSU/McQUAY/TICA)", "M56b (TRUMA)" };
static const bc7215FormatPkt_t zpmezqzipprw[] = { {{.inByte=0x34}, {0x14, 0x1d, 0x10, 0xfd, 0x14, 0x1d, 0x09, 0xfd, 0x9c, 0x9c, 0x12, 0x0a, 0x77, 0x9d, 0x38, 0xf8, 0x00, 0x00, 0xfa, 0x7f, 0xb5, 0x1a, 0x97, 0x02, 0x48, 0x00, 0x3e, 0x01, 0x48, 0x00, 0xea, 0x00}}, {{.inByte=0x35}, {0x13, 0x9D, 0x24, 0xDD, 0x13, 0x7D, 0x69, 0x3D, 0x9D, 0x1D, 0x2E, 0xDB, 0xF2, 0x9B, 0xBD, 0xFE, 0x0F, 0x02, 0xCE, 0x5F, 0x81, 0x3A, 0xA3, 0x22, 0x74, 0x00, 0x75, 0x05, 0x73, 0x00, 0x26, 0x13}}, {{.inByte=0x21}, {0x10, 0xBD, 0x06, 0x5D, 0x06, 0x5D, 0x2B, 0x9D, 0x1F, 0x19, 0x35, 0x4D, 0x1A, 0xA7, 0x72, 0xF9, 0x00, 0x00, 0x22, 0x00, 0x44, 0x00, 0x66, 0x90, 0x0D, 0x00, 0x0A, 0x00, 0x48, 0x00, 0x39, 0x00}}, {{.inByte=0x36}, {0x1B, 0x1D, 0x17, 0xFD, 0x18, 0xBD, 0x0F, 0xBD, 0x9F, 0x1E, 0x5F, 0x83, 0x83, 0xC9, 0x2B, 0xFB, 0x84, 0x00, 0x84, 0x10, 0x06, 0x01, 0x90, 0x02, 0x2D, 0x00, 0xF5, 0x08, 0x13, 0x02, 0x2F, 0x03}}, {{.inByte=0x37}, {0x15, 0xDD, 0x0C, 0x7D, 0x0C, 0x3D, 0x04, 0xFD, 0x1F, 0x9F, 0x92, 0x88, 0x19, 0x22, 0xCB, 0xF8, 0x00, 0x80, 0x00, 0x10, 0xA9, 0x9A, 0x8B, 0x82, 0x37, 0xC3, 0x81, 0x8A, 0x21, 0xE7, 0x01, 0x20}} };
static const uint8_t dljatqndcxoh[] = {0x60, 0x00, 0x9e, 0xc8, 0x00, 0x04, 0x52, 0x60, 0x00, 0x1c, 0x26, 0x10, 0x00, 0x4a};
static const uint8_t ojrcowjtbwry[] = {0x64, 0x00, 0x02, 0x05, 0x2C, 0x04, 0xD5, 0x56, 0x01, 0x6C, 0x50, 0xC4, 0x12, 0x40, 0x0C};
static const uint8_t uxrcelseenvr[] = {0x66, 0x00, 0x1C, 0x16, 0x00, 0x00, 0x87, 0x05, 0x80, 0x00, 0x21, 0xC1, 0x60, 0x00, 0x08};
static const uint8_t vwkjjrvolqgh[] = {0x06, 0x01, 0x53, 0x04, 0x10, 0x04, 0x14, 0x10, 0x04, 0x00, 0x00, 0x04, 0x00, 0x04, 0x50, 0x10, 0x04, 0x14, 0x09, 0x00, 0x00, 0x00, 0x00, 0x50, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x50, 0x25};
static const uint8_t ujetucyygowi[] = {0x38, 0x00, 0xE9, 0x0D, 0x10, 0x00, 0x00, 0x00, 0x06};
static const uint8_t hfknxsttgfsv[] = {0x60, 0x00, 0x9e, 0xc8, 0x00, 0x04, 0x52, 0x60, 0x00, 0x8c, 0x26, 0x10, 0x00, 0xda};
static const uint8_t psnpylibjrln[] = {0x64, 0x00, 0x02, 0x05, 0x2C, 0x04, 0xD5, 0x56, 0x01, 0x6C, 0x50, 0xD0, 0x12, 0x40, 0x0C};
static const uint8_t wnpqrzpmwuxe[] = {0x66, 0x00, 0x1C, 0x14, 0x00, 0x00, 0x87, 0x05, 0x00, 0x00, 0x21, 0xC1, 0x40, 0x00, 0x08};
static const uint8_t mahcizamphiz[] = {0x06, 0x01, 0x53, 0x04, 0x10, 0x04, 0x14, 0x10, 0x04, 0x00, 0x00, 0x04, 0x00, 0x04, 0x44, 0x10, 0x04, 0x10, 0x09, 0x00, 0x00, 0x00, 0x00, 0x50, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x50, 0x25};
static const uint8_t vqtbtbudkmsk[] = {0x38, 0x00, 0xE9, 0x0D, 0x10, 0x00, 0x00, 0x00, 0x06};
static const bc7215DataVarPkt_t* shnklcxaqppa[] = { (bc7215DataVarPkt_t*)hfknxsttgfsv, (bc7215DataVarPkt_t*)psnpylibjrln, (bc7215DataVarPkt_t*)wnpqrzpmwuxe, (bc7215DataVarPkt_t*)mahcizamphiz, (bc7215DataVarPkt_t*)vqtbtbudkmsk };
static const bc7215DataVarPkt_t* kwniwryzbdqn[] = { (bc7215DataVarPkt_t*)dljatqndcxoh, (bc7215DataVarPkt_t*)ojrcowjtbwry, (bc7215DataVarPkt_t*)uxrcelseenvr, (bc7215DataVarPkt_t*)vwkjjrvolqgh, (bc7215DataVarPkt_t*)ujetucyygowi };
static const uint8_t kqhvphdpbtpb = sizeof(shnklcxaqppa)/sizeof(struct bc7215DataVarPkt_t*);
static const uint8_t sroodvqdigbh[] = {0x23, 0xCB, 0x26};
static const uint8_t stgqkuoucjmg[] = {0x02, 0x20, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x06};
static const uint8_t abgtrwyfidmh[] = {0x00, 0x00, 0x36, 0x1B, 0x5D, 0x12, 0x3D, 0x1B, 0x7D, 0x02, 0x9D, 0x1F, 0x9E, 0x21, 0x60, 0x06, 0x53, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x10, 0x30, 0x00, 0x21, 0x0F, 0xC6, 0x0F, 0x20, 0x0F, 0xC6, 0x0F, 0x3F, 0x50, 0x60, 0x00, 0x4d, 0xb2, 0xde, 0x21, 0x07, 0xf8, 0x4d, 0xb2, 0xde, 0x21, 0x07, 0xf8, 0x00, 0x00};
static const uint8_t lrehdpmkgtmn[] = {0x28, 0x00, 0x68, 0xc2, 0x3d, 0x0f, 0x0f, 0x00, 0x00};
static const uint8_t bivolxnzzmfi[] = {0x28, 0x00, 0x68, 0xc2, 0x3d, 0x0f, 0xf0, 0x28, 0x00, 0x68, 0x12, 0xed, 0x0f, 0xf0};
static const uint8_t qvuqtkbvujjo[] = {0xB8, 0x00, 0x01, 0x10, 0x00, 0x40, 0xbf, 0xff, 0x00, 0xe6, 0x19, 0x89, 0x76, 0x01, 0xfe, 0x3f, 0xc0, 0x29, 0xd6, 0x16, 0xe9, 0x01, 0xfe, 0xa0, 0x5f, 0xb8, 0x00, 0x01, 0x10, 0x00, 0x40, 0xbf, 0xff, 0x00, 0xe6, 0x19, 0x89, 0x76, 0x01, 0xfe, 0x3f, 0xc0, 0x29, 0xd6,  0x16, 0xe9, 0x01, 0xfe, 0x90, 0x6f};
static const uint8_t aouwrujpaztm[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x80, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x09, 0x30, 0xa1, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0e};
static const uint8_t vhfynacxtmnb[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x78, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfc, 0x08, 0x30, 0x91, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3e};
static const uint8_t vxfqezcnwxpd[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x90, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x0b, 0x41, 0x89, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x03, 0x20};
static const uint8_t rowxxcmqcmsr[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x08, 0x01, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x1a, 0x40, 0x89, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x10, 0x24, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0x00, 0xac};
static const uint8_t ciufpmfcmooy[] = {0x30, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0x78, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfc, 0x08, 0x30, 0x91, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3e};
static const uint8_t wyjlxfrdarhw[] = {0x20, 0x00, 0x14, 0xeb, 0xc1, 0x3e, 0x40, 0x00, 0x14, 0xeb, 0x98, 0x91, 0x04, 0x00, 0x00, 0x00};
static const uint8_t qlhchaocgvwk[] = {0x48, 0x00, 0x1C, 0x28, 0x54, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x48, 0x00, 0x1C, 0x24, 0x49, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1a};
static const uint8_t xczqirpihapm[] = {0x00, 0x00, 0x33, 0x1A, 0x1D, 0x13, 0x1D, 0x1A, 0x1D, 0x01, 0x3D, 0x1E, 0x9B, 0x19, 0x9F, 0x2A, 0xA8, 0x07, 0x31, 0x00, 0x80, 0x00, 0x10, 0x38, 0x20, 0x38, 0x10, 0x70, 0x20, 0x70, 0x10, 0x3E, 0x87, 0x30, 0x00, 0xa8, 0x00, 0x02, 0xb2, 0x0f, 0x00, 0x00, 0x00, 0xc0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0xff, 0x71, 0x80, 0x11, 0xc0, 0xa8, 0x00, 0x02, 0x92, 0x0f, 0x00, 0x00, 0x00, 0xf0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0xe2, 0xfe, 0x71, 0x80, 0x11, 0xf0};
static const uint8_t tmcuunujvvxt[] = {0x00, 0x00, 0x30, 0x1A, 0xDD, 0x13, 0xBD, 0x1A, 0x7D, 0x01, 0x9D, 0x1F, 0x98, 0x37, 0xB0, 0x07, 0x2B, 0xAA, 0xF8, 0x00, 0x00, 0x38, 0x10, 0x38, 0x00, 0x70, 0x10, 0x70, 0x00, 0x9E, 0x4A, 0x3E, 0x27, 0x39, 0x0D  , 0xa8, 0x00, 0x02, 0xb2, 0x0f, 0x00, 0x00, 0x00, 0xc0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0xff, 0x71, 0x80, 0x11, 0xc0, 0xa8, 0x00, 0x02, 0x92, 0x0f, 0x00, 0x00, 0x00, 0xf0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0xe2, 0xfe, 0x71, 0x80, 0x11, 0xf0};
static const uint8_t iytojawjpdpw[] = {0x00, 0x00, 0x36, 0x1A, 0x1D, 0x13, 0x1D, 0x1A, 0x1D, 0x01, 0x3D, 0x1F, 0x9E, 0x37, 0xB5, 0x07, 0x07, 0x4C, 0xFB, 0x00, 0x00, 0x38, 0x10, 0x38, 0x00, 0x94, 0xE2, 0x28, 0xA3, 0x9E, 0xEA, 0x3E, 0x87, 0x0D, 0x0A, 0x70, 0x00, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x22, 0xff, 0x01, 0xa0, 0x11, 0xc0, 0x00, 0x00 };
static const uint8_t abrviblocjbf[] = {0x60, 0x00, 0x6A, 0xF5, 0x79, 0x20, 0x00, 0x53, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x4E, 0x60, 0x00, 0x6A, 0xF5, 0x79, 0x20, 0x00, 0x93, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x52};
static const uint8_t spqsxntkdvjb[] = {0x70, 0x00, 0x6A, 0x55, 0x79, 0x20, 0x00, 0x43, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x21, 0x00, 0x46, 0x70, 0x00, 0x6A, 0x55, 0x79, 0x20, 0x00, 0x83, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x21, 0x00, 0x4a};
static const uint8_t owujvsewldzf[] = {0x00, 0x00, 0x36, 0x15, 0xBD, 0x12, 0xFD, 0x15, 0x5D, 0x03, 0x9D, 0x1F, 0x9E, 0x23, 0x61, 0x08, 0x4F, 0xAA, 0xF8, 0x00, 0x00, 0x90, 0x10, 0x90, 0x00, 0x4E, 0x0F, 0x39, 0x0F, 0x31, 0x0F, 0x36, 0x0F, 0xFF, 0x4D, 0x20, 0x01, 0x4F, 0xB0, 0x30, 0xCF, 0x90, 0x2E, 0x20, 0x80, 0x70, 0xAA, 0x10, 0xDA, 0x40, 0x84, 0xD6, 0x84, 0xAE, 0x36, 0x4F, 0xB0, 0x30, 0xCF, 0x90, 0x2E, 0x20, 0x80, 0x70, 0xAA, 0x10, 0xDA, 0x40, 0x84, 0xD6, 0x84, 0xAE, 0x36, 0x00, 0x00};
static const uint8_t rfvsrlawowjl[] = {0x00, 0x00, 0x36, 0x15, 0x9D, 0x12, 0xDD, 0x15, 0x9D, 0x02, 0x1D, 0x1F, 0x9E, 0x22, 0x63, 0x08, 0x51, 0xAA, 0xF8, 0x00, 0x00, 0x30, 0x10, 0x30, 0x00, 0x4C, 0x0F, 0x0F, 0x0F, 0x4C, 0x0F, 0xBE, 0x0F, 0xFF, 0x4D, 0x60, 0x00, 0x4D, 0xB2, 0xDE, 0x21, 0x07, 0xF8, 0x4D, 0xB2, 0xDE, 0x21, 0x07, 0xF8, 0x00, 0x00};
static const extraValue_t olbtwhlypieh = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t jtfyeafstjuo = {.set={0x14, 0x0f, 0x10, 0x24, 0x13, 0x24, NULL}};
static const extraValue_t nxrdhuyhzxrv = {.set={0x13, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t xcoulaxlqduq = {.set={0x10, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t uwamrtxlewym = {.set={0x10, 0x24, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t ekzhvdorveqv = {.set={0x14, 0x00, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t zlpsuvgjiqwv = {.set={0x13, 0x20, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t undgocczxhwe = {.set={0x92, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t emfskyjcsedy = {.set={0x10, 0x0f, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const extraValue_t iixudukxafde = {.set={0x10, 0x00, 0x14, 0x00, 0xf0, 0xf0, NULL}};
static const extraValue_t fykqxdnfxwad = {.set={0x10, 0x0f, 0x13, 0x0f, 0xf0, 0xf0, NULL}};
static const extraValue_t lsawdfksfpqm = {.set={0x10, 0x00, 0x13, 0x00, 0xf0, 0xf0, NULL}};
static const extraValue_t evycgssopymu = {.set={0x13, 0x0f, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const extraValue_t nhfcnuxssqdy = {.set={0x10, 0x00, 0x13, 0x0f, 0xf0, 0xf0, NULL}};
static const extraValue_t holbhphlckyo = {.set={0x13, 0x20, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const extraValue_t ocwpowzplqnb = {.set={0x10, 0x0f, 0x14, 0x00, 0xf0, 0xf0, NULL}};
static const extraValue_t mdxfijtgnbep = {.set={0x13, 0x0f, 0x13, 0x20, 0xf0, 0xf0, NULL}};
static const extraValue_t rnlrefsedaas = {.set={0x13, 0x0f, 0x14, 0x01, 0xf0, 0xf0, NULL}};
static const extraValue_t wotkcqwgqcsh = {.set={0x92, 0x0f, 0x13, 0x24, 0xf0, 0xf0, NULL}};
static const extraValue_t xxklregglwyz = {.set={0x10, 0x00, 0x13, 0x00, 0x13, 0x20, NULL}};
static const extraValue_t lsxrgzunwiuv = {.set={0x10, 0x00, 0x92, 0x02, 0x13, 0x20, NULL}};
static const extraValue_t rbmxpyedhqsi= {.set={0x10, 0x0f, 0x92, 0x40, 0x92, 0x21, NULL}};
static const extraValue_t pgplrbrnambo = {.set={0x30, 0x2f, 0x31, 0x2f, 0xf0, 0xf0, NULL}};
static const extraValue_t biyrtkflorjo = {.set={0x72, 0x2f, 0x32, 0x24, 0xf0, 0xf0, NULL}};
static const extraValue_t ebzbioplqjmm = {.set={0x72, 0x1f, 0x72, 0x2f, 0xf0, 0xf0, NULL}};
static const extraValue_t fhslhkxmjjqk = {.set={0x14, 0x0f, 0x10, 0x0f, 0xf0, 0xf0, hwwzherdhlek}};
static const extraValue_t umhmwualpgpc= {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, pbhzbtpsnpub}};
static const extraValue_t sealknfmgbfa = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, zdmxihfihoyr}};
static const extraValue_t aqtkpryarvtb = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, htavyzvrfvan}};
static const extraValue_t ygodycsenfrr = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, qhwczhuqttir}};
static const extraValue_t fdxkajqbzzan = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, xisjuykcoyqp}};
static const extraValue_t znsmeszcajgq = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, srutlrqbdill}};
static const extraValue_t dldneguofhfg = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, tvhwcvmsyyup}};
static const extraValue_t umwiydxghooo = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, znkmqvqilzyr}};
static const extraValue_t ujqhykhpmude = {.set={0x13, 0x0f, 0x13, 0x20, 0xf0, 0xf0, vwscklnffyeu}};
static const extraValue_t xhvvxndvofwx = {.set={0x91, 0x2f, 0x91, 0x09, 0xf0, 0xf0, usqyxwejuzcf}};
static const extraValue_t zmhblajtiiim = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, yybzbksdpajd}};
static const extraValue_t iokfcjotdmmq = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, hwexjkkeehcg}};
static const struct fehyfyrgmlkh snjhobcqrytl;
static const struct fehyfyrgmlkh yhyzffwbghzj;
static const struct fehyfyrgmlkh xrcfyxoultdq;
static const struct fehyfyrgmlkh lnxumgzntqwn;
static const struct fehyfyrgmlkh negidwahpefw;
static const struct fehyfyrgmlkh cymtnhfkrgtc;
static const struct fehyfyrgmlkh rvwpmredthnx;
static const struct fehyfyrgmlkh bfynarpwhgxo;
static const extraValue_t eyvjsnhgibgz = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const srbjiaxreyht*)&snjhobcqrytl}};
static const extraValue_t goquiopzgski = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const srbjiaxreyht*)&yhyzffwbghzj}};
static const extraValue_t ancqczfcjgbu = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const srbjiaxreyht*)&xrcfyxoultdq}};
static const extraValue_t lbldedfcqxoj = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const srbjiaxreyht*)&lnxumgzntqwn}};
static const extraValue_t emvapmianrew = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const srbjiaxreyht*)&negidwahpefw}};
static const extraValue_t hiloxabfxord = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const srbjiaxreyht*)&cymtnhfkrgtc}};
static const extraValue_t rkaabhrcosee = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const srbjiaxreyht*)&rvwpmredthnx}};
static const extraValue_t kwukecrusnya = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const srbjiaxreyht*)&bfynarpwhgxo}};
static const extraValue_t ipinhabavepz = {.kbuoarkttzag={82, 13, 0, 0}};
static const struct vsghnouiwbyk nqcbntpcorjm = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 134, {35,32,35,32}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0, 0, 0x07, 0, hsuvxgtgltjj }, { 0x83, 2, 0x70, 4, vsldpvefbakr }, { 0, 0, 0x30, 4, dvtgclyxpwol }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, neblmufxjobh, &eftthwofcwcr };
static const struct vsghnouiwbyk lavqdnlmfywx = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 67, {35,32,0,0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq}, { 0, 0, 0x07, 0, hsuvxgtgltjj}, { 0, 0, 0x30, 4, tgvozcdkwizi}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vvivsaqmctsn, &eftthwofcwcr };
static const struct vsghnouiwbyk uqxtkwpbvaef = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq}, { 0, 0, 0x07, 0, hsuvxgtgltjj}, { 0, 0, 0x30, 4, tgvozcdkwizi}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk yhyihafcrqzf = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 216, {64,152,0,0}, { 1, 6, 0x1E, 1, qlbsybjbuuwq }, { 1, 5, 0x70, 4, nzrkfuvfonaq }, { 1, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dyoerhuugkim, &flrccffprjxa };
static const struct vsghnouiwbyk rdrmpuilokvu = { {0, 0, 0 , 0, 0, 0, 0}, 0x34, 43, {43,0,0,0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq}, { 0, 0, 0x07, 0, hsuvxgtgltjj}, { 0, 0, 0x70, 4, ctwleblehvbl}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 9}, 3, 0x70}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk bbtufostpjbn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, pqzbdwgjzgjg}, { 0, 0, 0x07, 0, fonpcaohdilk}, { 0, 0, 0x30, 4, ygdgsrknfpiy}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk axvbwdtfvhkc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, pqzbdwgjzgjg}, { 0, 0, 0x07, 0, fumlhnuvtjti}, { 0, 0, 0x30, 4, tgvozcdkwizi}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk qsmxzwgieita = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq}, { 0, 0, 0x07, 0, fumlhnuvtjti}, { 0, 0, 0x30, 4, tgvozcdkwizi}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk wufgaucrdccc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq}, { 0, 0, 0x07, 0, fumlhnuvtjti}, { 0, 0, 0x30, 4, ygdgsrknfpiy}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk dxwdteyifhxf = { {0, 1, 0, 0, 0, 1, 0}, 0x36, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, qlbsybjbuuwq}, { 0, 1, 0x07, 0, hsuvxgtgltjj}, { 0, 1, 0x30, 4, tgvozcdkwizi}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, romdggzovziq, NULL };
static const struct fehyfyrgmlkh yhyzffwbghzj = {NULL, &dxwdteyifhxf, 1, 255};
static const struct vsghnouiwbyk gcxkgmwfmkkv = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 2, 0x0f, 0, qlbsybjbuuwq}, { 0, 1, 0x07, 0, hsuvxgtgltjj}, { 0, 1, 0x30, 4, tgvozcdkwizi}, { 0x80, 0, 0, 0, NULL}, &goquiopzgski, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, cxxqpwnfospn, NULL };
static const struct vsghnouiwbyk tvyphljcxzkw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 1, 0xf8, 3, jlxcxegylhom}, { 0, 6, 0xe0, 5, vfbfuutoazdp}, { 0, 4, 0xe0, 5, vukdbvtfigfk}, { 0, 11, 0x07, 0, tfnbefmjojvh}, &fhslhkxmjjqk, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 9, 0x20}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &vhednltgggkl };
static const struct vsghnouiwbyk kppvtjneyxhb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 1, 0xf8, 3, jlxcxegylhom}, { 0, 6, 0xe0, 5, vfbfuutoazdp}, { 0, 4, 0xe0, 5, balsfqyllobd}, { 0, 11, 0x07, 0, tfnbefmjojvh}, &fhslhkxmjjqk, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 9, 0x20}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk cceakbeevmud = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 8, 0xff, 0, hzaxbgzfvbgn}, { 0, 0, 0xf0, 4, tajyfdalqtrk}, { 0, 9, 0x03, 0, tgvozcdkwizi}, { 0, 0, 0x07, 0, jprvapuookmy}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk xeqmegjnmmpr = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 144, {72, 72, 0, 0}, { 0, 5, 0xf0, 4, pqzbdwgjzgjg}, { 0, 6, 0x07, 0, vdgjgcoiublr}, { 0, 6, 0xC0, 6, tgvozcdkwizi}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 6, 0x06}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, fwastflmujzt, NULL };
static const struct vsghnouiwbyk zkopkesbzzkw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 1, 0x1f, 0, nemjsunvswft }, { 0, 4, 0x70, 4, aegickjxmxsj }, { 0, 4, 0x03, 0, gwmvscjwshzk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 5, 0xc0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, trsclbhfsdgr, &tkrayuuyqcxh };
static const struct vsghnouiwbyk kaskusfbgaxm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, auwyugwmwlso }, { 0, 6, 0x0f, 0, niaotlqdftsv }, { 0, 8, 0x07, 0, xknpcbptryfb }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &nbadiwmcydfa };
static const struct vsghnouiwbyk vxpodajlcgua = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, auwyugwmwlso }, { 0, 6, 0x0f, 0, niaotlqdftsv }, { 0, 8, 0x07, 0, xknpcbptryfb }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &sybcvgmdylst };
static const struct vsghnouiwbyk ljfouolbospn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, evrgvsxldwse }, { 0, 6, 0x0f, 0, niaotlqdftsv }, { 0, 8, 0x07, 0, xknpcbptryfb }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk zpfemwcmdlhc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, auwyugwmwlso }, { 0, 6, 0x0f, 0, niaotlqdftsv }, { 0, 8, 0x07, 0, xzzewdxxicyp }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &vonnpwtehkpp };
static const struct vsghnouiwbyk zaqvffklbcyp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, hmcmmhtpafcl }, { 0, 6, 0x0f, 0, niaotlqdftsv }, { 0, 8, 0x07, 0, xzzewdxxicyp }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk gpqtamyqeqso = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, auwyugwmwlso}, { 0, 2, 0x07, 0, umjxfsvzcsro}, { 0, 0, 0xe0, 5, zhfepltcdgom}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk tzipwgwupqcm = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, duzqslhlvrbd}, { 0, 2, 0x07, 0, bafqaozlnera}, { 0, 0, 0xe0, 5, qogdydoechiy}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk rlfryyoglzrw = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, duzqslhlvrbd}, { 0, 2, 0x07, 0, umjxfsvzcsro}, { 0, 0, 0xC0, 6, watlqftdktqz}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk ebfnvsnflmhb = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, duzqslhlvrbd}, { 0, 2, 0x07, 0, bafqaozlnera}, { 0, 0, 0xC0, 6, watlqftdktqz}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk fbvhyfrcgtcj = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, duzqslhlvrbd}, { 0, 2, 0x0f, 0, usdftdsdonen}, { 0, 0, 0xff, 0, cdtozclqdgpe}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk xrytsfutulct = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, duzqslhlvrbd}, { 0, 2, 0x07, 0, bafqaozlnera}, { 0, 0, 0xe0, 5, wiesewazwfjj}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk lojhanzqocev = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 4, 0x0f, 0, zmuhmziggshb }, { 0, 4, 0x30, 4, xramcvgpilnw }, { 0, 2, 0x07, 0, mctpbidjvrsb }, { 0, 0, 0, 0, NULL}, &jtfyeafstjuo, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 8}, 2, 0xde}, .xdvjpfttnymn.umavhyptrjjy = {{0, 8}, 4, 0x07}}, furfqjhejfgv, &uaqqeyvvobhp };
static const struct vsghnouiwbyk ynhxmgxuetst = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 160, {56, 104, 0, 0}, { 1, 9, 0xFE, 1, xgmfromrdrwl }, { 1, 5, 0x70, 4, cmvjkmxfoogt }, { 1, 10, 0x0f, 0, sodnmplfotvu }, { 0, 0, 0, 0, NULL}, &nxrdhuyhzxrv, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dyoerhuugkim, NULL };
static const struct vsghnouiwbyk lnixlwqvlojn = { {0, 1, 0, 0 ,0, 0, 0}, 0x36, 216, {64, 152, 0, 0}, { 1, 6, 0xfe, 1, dirmsniyzxmk }, { 1, 5, 0x70, 4, nzrkfuvfonaq}, { 1, 8, 0xf0, 4, sodnmplfotvu}, { 0, 0, 0, 0, NULL}, &nxrdhuyhzxrv, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, vixgnerqasdw, &xzgukzrwqvln };
static const struct vsghnouiwbyk iqdlpewgtvoz = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfe, 1, dirmsniyzxmk }, { 3, 5, 0x70, 4, nzrkfuvfonaq }, { 3, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL }, &nxrdhuyhzxrv, {.xdvjpfttnymn.yeltdjdwiegk = {{3, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{3, 9}, 9, 0x0f}}, tqokiavwcgfc, &gxwjutmejxvu };
static const struct vsghnouiwbyk qzqgxblouioh = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 128, {128, 0, 0, 0}, { 0, 0x83, 0xff, 0, hzaxbgzfvbgn }, { 0, 1, 0x70, 4, hsuvxgtgltjj }, { 0, 2, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &xcoulaxlqduq, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x0f}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, najmcimiaeia, NULL };
static const struct vsghnouiwbyk vmqwdugblegd = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 128, {128, 0, 0, 0}, { 0, 0x83, 0xff, 0, hzaxbgzfvbgn }, { 0, 1, 0x70, 4, hsuvxgtgltjj }, { 0, 2, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x0f}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, trsclbhfsdgr, NULL };
static const struct vsghnouiwbyk zloqfhsmqelq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0x0f, 0, qlbsybjbuuwq }, { 0, 0, 0x70, 4, eertyilkoola }, { 0, 1, 0x30, 4, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 1}, 0, 0x07}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk tqovgenkcvjz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0x0f, 0, huxsncyaliwc }, { 0, 0, 0x70, 4, eertyilkoola }, { 0, 1, 0x70, 4, enfaqllpjsst }, { 0, 0, 0x0f, 0, awcyzokqylxb }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 1}, 0, 0x07}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk nrbveilpjfbw = { {1, 1, 0, 0, 0, 0, 0}, 0x35, 80, {40, 40, 0, 0}, { 0, 0x1, 0xff, 0, hzaxbgzfvbgn }, { 0x00, 0, 0x07, 0, ezdvwkrfawmx }, { 0, 0, 0x30, 6, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0,8},1,0x16}}, fqgiigpemcaz, NULL };
static const struct fehyfyrgmlkh xrcfyxoultdq = {NULL, &nrbveilpjfbw, 1, 165};
static const struct vsghnouiwbyk zdmoxydkfenc = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0xff, 0, hzaxbgzfvbgn }, { 0, 0, 0x07, 0, ezdvwkrfawmx }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0x80, 0, 0, 0, NULL }, &ancqczfcjgbu, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0,8},1,0x16}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk nemfndaxmwgo = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 0x1, 0x0f, 0, huxsncyaliwc }, { 0, 2, 0x60, 5, hsuvxgtgltjj }, { 0, 3, 0xc0, 6, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk ahoqbmpvzfaz = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 0x0, 0xff, 0, klgznqqxptrf }, { 0, 4, 0xf0, 4, gzwyyudcsgwr }, { 0, 7, 0x0f, 0, mqgcthvkvikd }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, olhrfncspuea, NULL };
static const struct vsghnouiwbyk ahtjazfgxldu = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 64, {32,32,0,0}, { 0, 2, 0x0f, 0, qlbsybjbuuwq }, { 0, 0, 0x0f, 0, gpjvwopzumaf }, { 0, 2, 0xf0, 4, xoikkvjtpeyh }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, twbcxiqkpyzk, NULL };
static const struct vsghnouiwbyk ucprgxlmtvlr = { {0, 1, 0, 0, 0, 1, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, huxsncyaliwc }, { 0x00, 2, 0x07, 0, ajxmlmqzwxcy }, { 0, 0, 0xf0, 4, buuehtaguyng }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, mbtdrqfkrhlf, NULL };
static const struct vsghnouiwbyk qxlwosojboju = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 0x2, 0x0f, 0, qlbsybjbuuwq }, { 0x00, 10, 0x07, 0, lcfcdrxiqyzz }, { 0, 4, 0x70, 4, gezfbtusiggj }, { 0, 12, 0x07, 0, pipnpmrpkedm }, &umhmwualpgpc, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 3, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rhpoedahrstb, NULL };
static const struct vsghnouiwbyk amocaoutzpci = { {1, 0, 1, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 4, 0xf0, 4, mmaikokpzmiv }, { 0x00, 4, 0x0c, 2, rwxhlwtqcuxy }, { 0x80, 2, 0xe0, 5, oobbdzmmtido }, { 2, 1, 0xff, 0, dijowucrnhyr }, &jtfyeafstjuo, {.jylyhhlxgchq = (const bc7215DataVarPkt_t*)abgtrwyfidmh}, bhkyctzmvica, &sdjjmyazaobd };
static const struct vsghnouiwbyk tinqbldkzibi = { {1, 0, 1, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 4, 0xf0, 4, mmaikokpzmiv }, { 0x00, 4, 0x0c, 2, rwxhlwtqcuxy }, { 0x80, 2, 0xe0, 5, rxjkcgzrlsjg }, { 2, 1, 0xff, 0, khirzhpliszk }, &jtfyeafstjuo, {.jylyhhlxgchq = (const bc7215DataVarPkt_t*)abgtrwyfidmh}, bhkyctzmvica, NULL };
static const struct vsghnouiwbyk xkezaitiqdge = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xf0, 4, rnzkhkybayht }, { 0x00, 1, 0x70, 4, hsuvxgtgltjj }, { 0x40, 3, 0xf0, 4, mqgcthvkvikd }, { 0, 3, 0x0f, 0, asymsdykfyoh }, &pgplrbrnambo, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)lrehdpmkgtmn}, ebahprebnmen, NULL };
static const struct vsghnouiwbyk woieapgobeld = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0x80, 0, 0x0f, 0, kfznlnimdous }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0, 4, 0x40, 6, pvaqlkvrylaf }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk btzfcptiiggh = { {0, 1, 0, 0, 0, 0, 0}, 0x3e, 129, {64, 65, 0, 0}, { 0, 2, 0x1e, 1, qlbsybjbuuwq }, { 0x0, 1, 0x07, 0, shqsgblklcuc }, { 0, 1, 0x70, 4, mveqqstfduyf }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x30}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 5, 0xc0}}, uttppbcvqthg, NULL };
static const struct vsghnouiwbyk tppabwmpfsci = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0x0, 0, 0x70, 4, fumlhnuvtjti }, { 0, 1, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0x07, 0, vczurmymtuxp }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk jcfjaasgehsc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0x0, 0, 0x70, 4, wrcxnynhcibi }, { 0, 1, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 1}, 0, 0x0f}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk dwfwqcqaetxc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 80, {80, 0, 0, 0}, { 0, 1, 0x0f, 0, huxsncyaliwc }, { 0x0, 0, 0x70, 4, fumlhnuvtjti }, { 0, 1, 0x30, 4, ygdgsrknfpiy }, { 0, 0, 0x07, 0, vczurmymtuxp }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk ucejhiuyefrv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0x0, 0, 0x70, 4, wrcxnynhcibi }, { 0, 1, 0x30, 4, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 1}, 0, 0x0f}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk bxqzmmiuriyv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0x0, 0, 0x70, 4, fumlhnuvtjti }, { 0, 1, 0x30, 4, ygdgsrknfpiy }, { 0, 0, 0x0f, 0, qkjrwmuzbyzt }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk eqerrehxcrry = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 112, {16, 40, 16, 40}, { 1, 3, 0xf0, 4, qlbsybjbuuwq }, { 0x81, 0, 0xc0, 6, iquqznqnoydo }, { 1, 1, 0x30, 4, ygdgsrknfpiy }, { 0, 0, 0xc0, 6, ploddrlwbsqf }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0xc0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 9}, 0, 0xc0}}, rruxbybbhcov, NULL };
static const struct vsghnouiwbyk irfhqjyyjfex = { {0, 0, 1, 0, 0, 0, 0}, 0x37, 40, {40, 0, 0, 0}, { 0x40, 3, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 1, 0x70, 4, hsuvxgtgltjj }, { 0, 3, 0xf0, 4, mqgcthvkvikd }, { 0, 3, 0x0f, 0, djntjwrzxoau }, &biyrtkflorjo, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)bivolxnzzmfi}, ebahprebnmen, NULL };
static const struct vsghnouiwbyk rpujthbsfwef = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0x0f, 0, rlymjpnqwqxi }, { 0x0, 3, 0x70, 4, vdgjgcoiublr }, { 0, 2, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &lsawdfksfpqm, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk srxdyhqmibfa = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 7, 0xe0, 5, vfbfuutoazdp }, { 0, 5, 0xe0, 5, vukdbvtfigfk }, { 0, 12, 0x07, 0, tfnbefmjojvh }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &hotyxxcmorep };
static const struct vsghnouiwbyk dhofleujcyqk = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 160, {112, 48, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 7, 0xe0, 5, vfbfuutoazdp }, { 0, 5, 0xe0, 5, vukdbvtfigfk }, { 0, 12, 0x07, 0, tfnbefmjojvh }, &sealknfmgbfa, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 9}, 10, 0x10}}, vixgnerqasdw, NULL };
static const struct vsghnouiwbyk fgmnwssblgaj = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 160, {112, 48, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 7, 0xe0, 5, vfbfuutoazdp }, { 0, 5, 0xe0, 5, vukdbvtfigfk }, { 0, 12, 0x07, 0, tfnbefmjojvh }, &aqtkpryarvtb, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 9}, 10, 0x10}}, vixgnerqasdw, NULL };
static const struct vsghnouiwbyk xgptoowiyydc = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 0x1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 6, 0xf0, 4, rnuwicqokfnq }, { 0, 5, 0xc0, 6, ygdgsrknfpiy }, { 0, 1, 0x07, 0, dhljfflougxp }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &gxanzhyuafjw };
static const struct vsghnouiwbyk ewjtujleqbzy = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 136, {112, 24, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 7, 0xe0, 5, vfbfuutoazdp }, { 0, 5, 0xe0, 5, vukdbvtfigfk }, { 0, 12, 0x07, 0, tfnbefmjojvh }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0xc0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk hyhmmikyarju = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 88, {88, 0, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 6, 0xe0, 5, owzoglwzsxda }, { 0, 5, 0xe0, 5, dyzevacnxdjd }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk sjcrexjwrwdo = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 88, {88, 0, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 6, 0xe0, 5, owzoglwzsxda }, { 0, 4, 0xe0, 5, vukdbvtfigfk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, yidkopkslqak, NULL };
static const struct vsghnouiwbyk zgncyrorazyy = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq }, { 0x0, 5, 0x70, 4, ybuezpmusfwy }, { 0, 4, 0x07, 0, eobqxjqhbanf }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 9}, 0, 0x02}}, byrdqdaczwxz, NULL };
static const struct vsghnouiwbyk bhflfavdejpw = { {1, 1, 0, 0, 0, 0 ,0}, 0x37, 64, {16, 48, 0, 0}, { 1, 3, 0xf0, 4, qlbsybjbuuwq }, { 1, 5, 0xe0, 5, yzpeqodnfhra }, { 1, 1, 0x30, 4, tfyyqgwxvmya }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, bkdtbokwxvif, NULL };
static const struct vsghnouiwbyk azbagyhwbkam = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 4, 0xFF, 0, tjbeparnujnx }, { 0, 5, 0xe0, 5, vukdbvtfigfk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0xc0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 8}, 12, 5}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk swengmrqfiyi = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 7, 0xe0, 5, vfbfuutoazdp }, { 0, 5, 0xe0, 5, vukdbvtfigfk }, { 0, 12, 0x0f, 0, zkbfjyvupcpk }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 4, 0x2f}}, rktudivhsjgb, NULL };
static const struct vsghnouiwbyk nfbkkzawavpt = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 7, 0xe0, 5, vfbfuutoazdp }, { 0, 5, 0xe0, 5, vukdbvtfigfk }, { 0, 12, 0x0f, 0, zkbfjyvupcpk }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0xf0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 4, 6}}, dlpifexbyqlw, NULL };
static const struct vsghnouiwbyk bhpjvcjfkgvb = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, qlbsybjbuuwq }, { 0x0, 2, 0x70, 4, nbgcalmcrydn }, { 0, 1, 0x30, 4, watlqftdktqz }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dsuxtremdabv, NULL };
static const struct vsghnouiwbyk stftccshxgnw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 136, {136, 0, 0, 0}, { 0, 0x46, 0xFF, 0, nuyihfymrlxy }, { 0x0, 5, 0xf0, 4, txsbffnaanwl }, { 0, 5, 0x0f, 0, obqdvlxymdam }, { 0, 0, 0, 0, NULL }, &uwamrtxlewym, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 8, 0x20}, .xdvjpfttnymn.umavhyptrjjy = {{0,0}, 0, 0}}, vqivsbeaooll, NULL };
static const struct vsghnouiwbyk cqnelpafgwig = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, huxsncyaliwc }, { 0, 1, 0x07, 0, ygcjwyoxujmy }, { 0, 2, 0x07, 0, qtpbyvcfejdx }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0xc0}, .xdvjpfttnymn.umavhyptrjjy = {{0,0}, 0, 0}}, rjvlmqcbgtfl, &isxavciifnyk };
static const struct vsghnouiwbyk nzdbxyzkviod = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, auwyugwmwlso }, { 0x0, 8, 0xe0, 5, bafqaozlnera }, { 0, 6, 0x60, 5, watlqftdktqz }, { 0, 4, 0x07, 0, obdcmcvhlbdy }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 6, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 4, 0x07}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk rhprqrmokjlb = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, auwyugwmwlso }, { 0x0, 8, 0xe0, 5, bafqaozlnera }, { 0, 6, 0x60, 5, watlqftdktqz }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 6, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 4, 0x07}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk ezsuqdpbzkob = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, auwyugwmwlso }, { 0x0, 4, 0x07, 0, skpwqtbrungz }, { 0, 6, 0x60, 5, watlqftdktqz }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 6, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 4, 0x07}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk htzcsdyeeraq = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, auwyugwmwlso }, { 0x0, 8, 0xe0, 5, bafqaozlnera }, { 0, 6, 0xe0, 5, qogdydoechiy }, { 0, 4, 0x07, 0, obdcmcvhlbdy }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 6, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 4, 0x07}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk uatfwllghqdo = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, aekximikujqn }, { 1, 1, 0x07, 0, einaxguqxgdv }, { 1, 0, 0x03, 0, ygdgsrknfpiy }, { 2, 1, 0xff, 0, bxstpkifthlt }, &ygodycsenfrr, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dvlmbpsinqoo, &ymzofyqomcwt };
static const struct vsghnouiwbyk zjaazwkayftb = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 112, {16, 96, 0, 0}, { 1, 1, 0xf0, 4, aekximikujqn }, { 1, 1, 0x07, 0, einaxguqxgdv }, { 1, 0, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 3}, 0, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, lrwothecqnqk, NULL };
static const struct vsghnouiwbyk hzvlxeswzobp = { {0, 1, 0, 0 ,0, 0 ,0}, 0x34, 184, {24, 160, 0, 0}, { 1, 3, 0xff, 0, ybxjhnxfyjgb }, { 1, 0, 0x3f, 0, cxsyqmosciuu }, { 1, 1, 0xff, 0, lhegdqcihvky }, { 1, 16, 0xff, 0, zbzgguwefrup }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, lrwothecqnqk, NULL };
static const struct vsghnouiwbyk vneficeevhug = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 3, 0xf0, 4, aekximikujqn }, { 0, 3, 0x07, 0, einaxguqxgdv }, { 0, 2, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, &gxanzhyuafjw };
static const struct vsghnouiwbyk dgilrfxeerlc = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 3, 0xf0, 4, qlbsybjbuuwq }, { 0, 3, 0x07, 0, einaxguqxgdv }, { 0, 2, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct sxpegamfsrfd voimbfxlagws = { .cssjkjaqtock = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 168, {24, 144, 0, 0}, { 1, 12, 0xfe, 1, vmrjepqklhrp }, { 1, 14, 0x0f, 0, ollwywbmbdun }, { 1, 14, 0xf0, 4, riybiayodery }, { 1, 8, 0x0f, 0, zgmshkbdxzgj }, &olbtwhlypieh, {.dmfwafbbczce = nexkiawgsmhd}, wiuiioibmfwg, &yqpnditmwonr }, .hffaidvvtesl = ollwywbmbdun };
static const struct vsghnouiwbyk fvcrjmuwsxkv = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 136, {24, 112, 0, 0}, { 0x41, 12, 0xfe, 1, vmrjepqklhrp }, { 0x61, 12, 0x0f, 0, (const uint8_t*)&voimbfxlagws }, { 1, 12, 0xf0, 4, riybiayodery }, { 1, 8, 0x0f, 0, zgmshkbdxzgj }, &ebzbioplqjmm, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)qvuqtkbvujjo}, wiuiioibmfwg, &yqpnditmwonr };
static const struct vsghnouiwbyk beoemlhmiccv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, nemjsunvswft }, { 0, 4, 0x30, 4, bbdoduitrwbi }, { 0, 4, 0x03, 0, gwmvscjwshzk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 5, 0x40}}, trsclbhfsdgr, &gxanzhyuafjw };
static const struct vsghnouiwbyk pneqdrabhsuz = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0xf0, 4, aekximikujqn }, { 0, 3, 0x07, 0, einaxguqxgdv }, { 0, 2, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk kghadgokegob = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0xf0, 4, aekximikujqn }, { 0, 3, 0x07, 0, einaxguqxgdv }, { 0, 2, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &sjktkrmdodrd };
static const struct vsghnouiwbyk ncxukazluhfy = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, nemjsunvswft }, { 0x80, 4, 0x30, 4, bbdoduitrwbi }, { 0, 4, 0x03, 0, gwmvscjwshzk }, { 0, 2, 0xff, 0, ggppmvgyklcq }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 5, 0x40}}, trsclbhfsdgr, NULL };
static const struct vsghnouiwbyk htuklbdisezz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0x0, 0, 0x70, 4, fumlhnuvtjti }, { 0, 1, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0x0f, 0, qkjrwmuzbyzt }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk omblkccmiqyr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, aekximikujqn }, { 0x0, 0, 0x70, 4, fumlhnuvtjti }, { 0, 1, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0x0f, 0, qkjrwmuzbyzt }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk sonenrionuiu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0x1f, 0, nemjsunvswft }, { 0x80, 4, 0x30, 4, kzndtcqngbci }, { 0, 4, 0x03, 0, gwmvscjwshzk }, { 0, 2, 0x10, 4, cztawhzyjhpm }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3},5, 0x04}}, olhrfncspuea, &uaqqeyvvobhp };
static const struct vsghnouiwbyk ewfrcrrklmuk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, nemjsunvswft }, { 0x80, 4, 0x30, 4, bbdoduitrwbi }, { 0, 4, 0x0c, 2, gwmvscjwshzk }, { 0, 2, 0xff, 0, pdymzidejhjm }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 5, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 9}, 5, 0x80}}, trsclbhfsdgr, NULL };
static const struct vsghnouiwbyk wglwzvhacgmn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0x1f, 0, nemjsunvswft }, { 0x80, 4, 0x30, 4, bbdoduitrwbi }, { 0, 4, 0x03, 0, gwmvscjwshzk }, { 0, 2, 0x10, 4, cztawhzyjhpm }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 9}, 1, 0x02}}, olhrfncspuea, NULL };
static const struct vsghnouiwbyk rszgjuhrfwgm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, auwyugwmwlso }, { 0, 6, 0x0f, 0, niaotlqdftsv }, { 0, 8, 0x07, 0, xknpcbptryfb }, { 0, 12, 0xff, 0, qdwabnumooho}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &ksrayuarwjtj };
static const struct vsghnouiwbyk gmcpklxaurat = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 113, {113, 0, 0, 0}, { 0, 7, 0x0f, 0, auwyugwmwlso}, { 0, 6, 0x0f, 0, niaotlqdftsv}, { 0, 8, 0x07, 0, xknpcbptryfb}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, wleslucdzswj, NULL };
static const struct vsghnouiwbyk alhjruiazrwi = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 168, {56, 56, 56, 0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq }, { 0, 5, 0xf0, 4, jnwrrmemhpqv }, { 0, 3, 0x03, 0, tgvozcdkwizi }, { 0, 5, 0x20, 5, zemiirzsdbky }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, ikrgztxhbhme, NULL };
static const struct vsghnouiwbyk dzosszksdzoo = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, auwyugwmwlso }, { 0x80, 6, 0x0f, 0, niaotlqdftsv }, { 0, 8, 0x07, 0, xknpcbptryfb }, { 0, 8, 0xf8, 0, aobugicxmdfl }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk myjcflmkkgsc = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 168, {56, 56, 56, 0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq }, { 0, 5, 0xf0, 4, gzobhywjwzgu }, { 0, 3, 0x03, 0, ygdgsrknfpiy }, { 0, 5, 0x20, 5, zemiirzsdbky }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, ikrgztxhbhme, NULL };
static const struct vsghnouiwbyk ukpfcrfhrgug = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0xff, 0, pyxakjclofwa }, { 0, 0, 0x07, 0, fumlhnuvtjti }, { 0, 2, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk kqrwyfcvgnlz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x0f, 0, huxsncyaliwc }, { 0, 0, 0x07, 0, fumlhnuvtjti }, { 0, 2, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk paeqqjdsrfnt = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0, 0, 0x70, 4, fumlhnuvtjti }, { 0, 1, 0x30, 4, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 1}, 0, 0x87}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk dbjsltpmbgoq = { {1, 0, 0, 1, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 7, 0x1e, 1, qlbsybjbuuwq }, { 0, 5, 0x07, 0, hsuvxgtgltjj }, { 0, 6, 0xff, 0, roldsnmewkty }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, rhpoedahrstb, NULL };
static const struct vsghnouiwbyk xttfnmbgjwal = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 224, {112, 112, 0, 0}, { 1, 7, 0x0f, 0, auwyugwmwlso }, { 1, 6, 0x0f, 0, niaotlqdftsv }, { 0x01, 8, 0x07, 0, xknpcbptryfb }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1,9},5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0,0}, 0, 0}}, dyoerhuugkim, &zzpndcuiqygi };
static const struct vsghnouiwbyk wyksgpticuwi = { {1, 1, 0, 0, 0, 0, 0}, 0x35, 88, {44, 44, 0, 0}, { 0, 0x1, 0xff, 0, hzaxbgzfvbgn }, { 0x00, 0, 0x07, 0, ezdvwkrfawmx }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, fqgiigpemcaz, NULL };
static const struct fehyfyrgmlkh lnxumgzntqwn = {NULL, &wyksgpticuwi, 1, 165};
static const struct vsghnouiwbyk xocvywzuttti = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 0x1, 0xff, 0, hzaxbgzfvbgn }, { 0x00, 0, 0x07, 0, ezdvwkrfawmx }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0x80, 0, 0, 0, NULL }, &lbldedfcqxoj, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk yeobnxyjvwij = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0x0f, 0, imegbmhoswpz }, { 0x00, 1, 0x30, 4, zoxbzpgkrild }, { 0, 1, 0xc0, 6, bqkwjhxmdzlf }, { 0, 2, 0x0f, 0, wowphqlodpqt }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,9},0,0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, dikotbgrtiuo, NULL };
static const struct vsghnouiwbyk hiwirhjbknsp = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0x0f, 0, mscxujnqnuhc }, { 0x00, 1, 0x30, 4, zoxbzpgkrild }, { 0, 1, 0xc0, 6, bqkwjhxmdzlf }, { 0, 2, 0x0f, 0, bitfqvjznjnl }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,9},0,0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dikotbgrtiuo, NULL };
static const struct vsghnouiwbyk pkozyrktbizw = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0x0f, 0, mscxujnqnuhc }, { 0x00, 1, 0x30, 4, zoxbzpgkrild }, { 0, 1, 0xc0, 6, bqkwjhxmdzlf }, { 0, 2, 0x0f, 0, wowphqlodpqt }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,9},0,0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dikotbgrtiuo, NULL };
static const struct vsghnouiwbyk fkblteeqdvec = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0x0f, 0, yqfsdnalmyna }, { 0x00, 1, 0x30, 4, zoxbzpgkrild }, { 0, 1, 0xc0, 6, bqkwjhxmdzlf }, { 0, 2, 0x0f, 0, bitfqvjznjnl }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,9},0,0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dikotbgrtiuo, NULL };
static const struct vsghnouiwbyk fndleauamszv = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 288, {144, 144, 0, 0}, { 0, 7, 0x0f, 0, qlbsybjbuuwq }, { 0x80, 6, 0x38, 3, qkzbyzcluece }, { 0, 9, 0x07, 0, ctwleblehvbl }, { 0, 8, 0x07, 0, fevrkzpoqnlu }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x20}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, wkhvrdgxemas, &vmsyeoerpcbo };
static const struct vsghnouiwbyk zuvkfvvzyyvr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 144, {144, 0, 0, 0}, { 0, 7, 0x0f, 0, qlbsybjbuuwq }, { 0x80, 6, 0x38, 3, qkzbyzcluece }, { 0, 9, 0x07, 0, ctwleblehvbl }, { 0, 8, 0x07, 0, fevrkzpoqnlu }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x20}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk mzcdqaqfysil = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 184, {40, 144, 0, 0}, { 1, 7, 0x0f, 0, auwyugwmwlso }, { 0x1, 6, 0x07, 0, qkzbyzcluece }, { 1, 8, 0x07, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, dyoerhuugkim, NULL };
static const struct vsghnouiwbyk yplqlejdjgfi = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 184, {40, 144, 0, 0}, { 1, 7, 0x0f, 0, qlbsybjbuuwq }, { 0x81, 6, 0x38, 3, niaotlqdftsv }, { 1, 9, 0x03, 0, tgvozcdkwizi }, { 1, 8, 0x07, 0, fevrkzpoqnlu }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x20}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, dyoerhuugkim, &iavlxfeyybjd };
static const struct vsghnouiwbyk nvryyqqoomlz = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 88, {24, 64, 0, 0}, { 1, 6, 0xf0, 4, hnqfngbztkvd }, { 1, 6, 0x07, 0, bafqaozlnera }, { 1, 4, 0xe0, 5, aorqinwjsvvt }, { 0, 0, 0, 0, NULL }, &iixudukxafde, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 3}, 2, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{1,3},6,0x08}}, wiuiioibmfwg, NULL };
static const struct vsghnouiwbyk hdxztezasnbk = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 136, {40, 48, 48, 0}, { 1, 1, 0xf0, 4, qlbsybjbuuwq }, { 1, 1, 0x07, 0, smlahnhsfqyk }, { 1, 2, 0x06, 1, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, tghubrggbsnn, &hpyguqhasgog };
static const struct vsghnouiwbyk bztrmruvgbmz = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 136, {40, 48, 48, 0}, { 1, 0, 0x1e, 1, qlbsybjbuuwq }, { 1, 1, 0x07, 0, smlahnhsfqyk }, { 1, 2, 0x06, 1, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, tghubrggbsnn, &gsrnsfjloqer };
static const struct vsghnouiwbyk letfeiyhgyvy = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 102, {51, 51, 0, 0}, { 0, 2, 0xf0, 4, auwyugwmwlso }, { 0, 1, 0x0f, 0, niaotlqdftsv }, { 0, 2, 0x07, 0, vsldpvefbakr }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x03}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, fqgiigpemcaz, &rrqwtapoxwws };
static const struct vsghnouiwbyk wnjkpivtckvq = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 2, 0xf0, 4, duzqslhlvrbd }, { 0x0, 2, 0x07, 0, umjxfsvzcsro }, { 0, 0, 0x70, 4, tsasjsbzwxie }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk uhnrnfbmaaio = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 6, 0xf0, 4, nvtfnxgsqyky }, { 1, 6, 0x07, 0, bafqaozlnera }, { 1, 4, 0xe0, 5, aorqinwjsvvt }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 3}, 6, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, wiuiioibmfwg, NULL };
static const struct vsghnouiwbyk dsiqvttdffga = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 6, 0xf0, 4, duzqslhlvrbd }, { 1, 6, 0x07, 0, bafqaozlnera }, { 1, 4, 0xe0, 5, aorqinwjsvvt }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 3}, 6, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, wiuiioibmfwg, NULL };
static const struct vsghnouiwbyk jhuxbtudabwa = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 120, {24, 96, 0, 0}, { 1, 2, 0xf0, 4, duzqslhlvrbd }, { 1, 2, 0x07, 0, bafqaozlnera }, { 1, 8, 0x18, 3, souulsuvkqvp }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, wiuiioibmfwg, NULL };
static const struct vsghnouiwbyk cwhedsgdrjao = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 120, {24, 96, 0, 0}, { 1, 2, 0xf0, 4, duzqslhlvrbd }, { 1, 2, 0x07, 0, bafqaozlnera }, { 1, 8, 0x18, 3, souulsuvkqvp }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, wiuiioibmfwg, NULL };
static const struct vsghnouiwbyk dsognanhpusz = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 86, {43, 43, 0, 0}, { 0, 2, 0xf0, 4, auwyugwmwlso }, { 0x80, 0, 0x0c, 2, pqvvecicvowt }, { 0, 0, 0x30, 4, ygdgsrknfpiy }, { 0, 4, 0x20, 5, vubaykzztfch }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, fqgiigpemcaz, NULL };
static const struct vsghnouiwbyk kjtwgbydsbrq = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 84, {24, 56, 4, 0}, { 1, 1, 0xf0, 4, auwyugwmwlso }, { 1, 0, 0xe0, 5, cnvzopxnosqn }, { 1, 2, 0x70, 4, xknpcbptryfb }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, ewcwtwtnjumd, NULL };
static const struct vsghnouiwbyk tvjbmiqkyvwz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {24, 64, 0, 0}, { 1, 6, 0xf0, 4, duzqslhlvrbd }, { 1, 6, 0x07, 0, bafqaozlnera }, { 1, 4, 0xe0, 5, aorqinwjsvvt }, { 0, 0, 0, 0, NULL }, &ekzhvdorveqv, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 3}, 6, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, wiuiioibmfwg, NULL };
static const struct vsghnouiwbyk zkgdfyieyoxv = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 4, 0xf0, 4, duzqslhlvrbd }, { 0x0, 4, 0x07, 0, bafqaozlnera }, { 0, 2, 0x70, 4, ghixxwbtroxk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0,3},4,0x08}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk kfiqxgisnmmy = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 152, {24, 128, 0, 0}, { 1, 4, 0x0f, 0, duzqslhlvrbd }, { 1, 2, 0x07, 0, bafqaozlnera }, { 1, 6, 0x07, 0, xbkwqzgpisrs }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, wiuiioibmfwg, NULL };
static const struct vsghnouiwbyk iewpqkzsaedj = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 128, {128, 0, 0, 0}, { 0, 6, 0x3e, 1, nemjsunvswft }, { 0, 5, 0xc0, 6, lcfcdrxiqyzz }, { 0, 5, 0x0c, 2, gwmvscjwshzk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, pwvdqwkpzxsd, NULL };
static const struct vsghnouiwbyk xngxarrljybh = { {0, 1, 0, 0 ,0, 0, 0}, 0x31, 96, {32, 32, 32, 0}, { 0, 0, 0x0f, 0, huxsncyaliwc }, { 0, 2, 0x07, 0, ajxmlmqzwxcy }, { 0, 0, 0x70, 4, buuehtaguyng }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, qjwvrgtjudlw, NULL };
static const struct vsghnouiwbyk bpebpxzcqusj = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {56, 120, 0, 0}, { 1, 10, 0x3e, 1, atzscyghbqee }, { 1, 7, 0x70, 4, tmjxndimiwqv }, { 1, 11, 0x70, 4, vsldpvefbakr }, { 1, 6, 0x04, 2, mwkgnbawnupn }, &fdxkajqbzzan, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 7, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, vixgnerqasdw, NULL };
static const struct vsghnouiwbyk jpskkxgsaugj = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 6, 0x3e, 1, nemjsunvswft }, { 0, 5, 0xe0, 5, gboajlxtrvem }, { 0, 5, 0x0e, 1, hmcqxpcagkyb }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, tynaglfwcjtt, &flrccffprjxa };
static const struct vsghnouiwbyk mrhrhhgqqtue = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 56, {12, 44, 0, 0}, { 1, 3, 0x0f, 0, qlbsybjbuuwq }, { 1, 4, 0x07, 0, hsuvxgtgltjj }, { 1, 3, 0xe0, 5, ylmeljrhbupr }, { 0, 0, 0, 0, NULL }, &uwamrtxlewym, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)iytojawjpdpw}, bcvrjesyhbss, &obdyrantbdfg };
static const struct vsghnouiwbyk sdnwwfepitur = { {0, 1, 1, 0, 0, 0, 0}, 0x31, 112, {12, 44, 12, 44}, { 3, 3, 0x0f, 0, qlbsybjbuuwq }, { 3, 4, 0x07, 0, hsuvxgtgltjj }, { 3, 3, 0xe0, 5, ylmeljrhbupr }, { 0, 0, 0, 0, NULL }, &uwamrtxlewym, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)xczqirpihapm}, qoxwndjnfccy, &qpwvppcoajoo };
static const struct vsghnouiwbyk vtknycnjzuot = { {0, 1, 1, 0, 0, 0, 0}, 0x36, 112, {12, 44, 12, 44}, { 3, 3, 0x0f, 0, qlbsybjbuuwq }, { 3, 4, 0x07, 0, hsuvxgtgltjj }, { 3, 3, 0xe0, 5, ylmeljrhbupr }, { 0, 0, 0, 0, NULL }, &uwamrtxlewym, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)tmcuunujvvxt}, qoxwndjnfccy, &qpwvppcoajoo };
static const struct vsghnouiwbyk wmdxzowfnxmt = { {0, 1, 1, 0, 0, 0, 0}, 0x37, 113, {12, 44, 13, 44}, { 3, 3, 0x1e, 1, qlbsybjbuuwq }, { 3, 4, 0x07, 0, hsuvxgtgltjj }, { 3, 3, 0xe0, 5, ylmeljrhbupr }, { 0, 0, 0, 0, NULL }, &uwamrtxlewym, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)tmcuunujvvxt}, lxeqknsnwmvy, &kxlehxjhafxr };
static const struct vsghnouiwbyk jaipseoqfjjd = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xF0, 4, qlbsybjbuuwq }, { 1, 2, 0x07, 0, hsuvxgtgltjj }, { 1, 3, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)aouwrujpaztm}, yfkkffuyjdjc, &uaqqeyvvobhp };
static const struct vsghnouiwbyk ticlibjvrnfr = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 120, {56, 64, 0, 0}, { 1, 1, 0xF0, 4, qlbsybjbuuwq }, { 1, 2, 0x07, 0, hsuvxgtgltjj }, { 1, 3, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)vhfynacxtmnb}, yfkkffuyjdjc, &uaqqeyvvobhp };
static const struct vsghnouiwbyk owovpmzrtkei = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0xF0, 4, qlbsybjbuuwq }, { 0, 4, 0x07, 0, wxkwcmkryxyu }, { 0, 4, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)wyjlxfrdarhw}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk ixhwaobvqsdk = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0xF0, 4, qlbsybjbuuwq }, { 0, 4, 0x0f, 0, iwibokxoamdr }, { 0, 4, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)wyjlxfrdarhw}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk nlbbipzajbsk = { {0, 1, 0, 0, 0, 1, 0}, 0x34, 104, {40, 64, 0, 0}, { 1, 1, 0xfe, 1, vmrjepqklhrp }, { 1, 0, 0x0f, 0, lejoqyagfyzp }, { 1, 0, 0x70, 4, ctwleblehvbl }, { 0, 0, 0, 0, NULL }, &emfskyjcsedy, {.xdvjpfttnymn.yeltdjdwiegk= {{1, 3}, 6, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, ewcwtwtnjumd, NULL };
static const struct vsghnouiwbyk qzfyfmozspcz = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 144, {56, 88, 0, 0}, { 1, 1, 0xF8, 3, jlxcxegylhom }, { 1, 2, 0x07, 0, hsuvxgtgltjj }, { 1, 3, 0x0f, 0, pdsivkkogkpw }, { 1, 1, 0x01, 0, mwkgnbawnupn }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)vxfqezcnwxpd}, yfkkffuyjdjc, NULL };
static const struct vsghnouiwbyk hinfjnehedmf = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 264, {56, 208, 0, 0}, { 1, 1, 0xF8, 3, jlxcxegylhom }, { 1, 2, 0x07, 0, hsuvxgtgltjj }, { 1, 3, 0x0f, 0, pdsivkkogkpw }, { 1, 1, 0x01, 0, mwkgnbawnupn }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)rowxxcmqcmsr}, yfkkffuyjdjc, NULL };
static const struct vsghnouiwbyk srwcsqpoanux = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 64, {48, 16, 0, 0}, { 0, 3, 0xFF, 0, hzaxbgzfvbgn }, { 0, 1, 0x0f, 0, nzxfabradldm }, { 0, 1, 0xf0, 4, tdwegvcedrpe }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 4, 0x40}}, pxkacdstmejh, NULL };
static const struct vsghnouiwbyk nechawtmavfr = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xF8, 3, jlxcxegylhom }, { 1, 2, 0x07, 0, hsuvxgtgltjj }, { 1, 3, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)aouwrujpaztm}, yfkkffuyjdjc, NULL };
static const struct vsghnouiwbyk xiumgqrccrjw = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 264, {24, 240, 0, 0}, { 1, 10, 0x3c, 2, qlbsybjbuuwq }, { 1, 22, 0x07, 0, hhhswelrvjuh }, { 1, 22, 0x70, 4, cnbszmkdlatp }, { 1, 8, 0xff, 0, lzedgpxidpwo }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 24, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, tfqcvjqqgksc, NULL };
static const struct vsghnouiwbyk jsmmifwtmhwr = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 344, {24, 320, 0, 0}, { 1, 10, 0x3c, 2, qlbsybjbuuwq }, { 1, 22, 0x07, 0, hhhswelrvjuh }, { 1, 22, 0x70, 4, cnbszmkdlatp }, { 1, 8, 0xff, 0, lzedgpxidpwo }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 24, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, tfqcvjqqgksc, NULL };
static const struct vsghnouiwbyk ljsxaptbeslq = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 224, {56, 168, 0, 0}, { 1, 4, 0x3e, 1, dirmsniyzxmk }, { 1, 3, 0x0f, 0, ziszrqxokrda }, { 1, 6, 0x07, 0, zdumkkqrzozd }, { 1, 2, 0x0f, 0, ntreoxngymvu }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 10, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, fxfxqyeahtnk, &fgteclqwvypk };
static const struct vsghnouiwbyk hsvzyjdwasju = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 296, {24, 272, 0, 0}, { 1, 10, 0x3c, 2, qlbsybjbuuwq }, { 1, 22, 0x0f, 0, rdgxenokefnn }, { 1, 22, 0x70, 4, xkbkyujymdhn }, { 1, 8, 0xff, 0, lzedgpxidpwo }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 24, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, tfqcvjqqgksc, NULL };
static const struct vsghnouiwbyk vkfadeonobsh = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 40, {40, 0, 0, 0}, { 0, 3, 0x0f, 0, auwyugwmwlso }, { 0, 2, 0x07, 0, etirvoycmsmy }, { 0, 2, 0x70, 4, ghixxwbtroxk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, yzwkptrlibny, NULL };
static const struct vsghnouiwbyk rtprmcyraybo = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0, 4, 0x70, 4, hlwjchgwhrxt }, { 0, 4, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 8}, 5, 0x41}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk onumnaqimutd = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 317, {5, 160, 152, 0}, { 2, 6, 0xfe, 1, dirmsniyzxmk }, { 2, 5, 0x70, 4, nzrkfuvfonaq }, { 2, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL }, &fykqxdnfxwad, {.xdvjpfttnymn.yeltdjdwiegk = {{2, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{1, 3}, 11, 0x80}}, bspfpjedoqeg, &dkmwaidgkket };
static const struct vsghnouiwbyk dacyvuezeond = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 200, {56, 144, 0, 0}, { 1, 10, 0x3e, 1, atzscyghbqee }, { 1, 7, 0x70, 4, kuynqvlswrys }, { 1, 11, 0x70, 4, vsldpvefbakr }, { 1, 6, 0x04, 2, mwkgnbawnupn }, &evycgssopymu, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 7, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{1, 9}, 6, 0x04}}, vixgnerqasdw, NULL };
static const struct vsghnouiwbyk xlyyyyguhirh = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 157, {5, 152, 0, 0}, { 1, 6, 0xfe, 1, dirmsniyzxmk }, { 1, 5, 0x70, 4, nzrkfuvfonaq }, { 1, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL }, &nxrdhuyhzxrv, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dyoerhuugkim, &xzgukzrwqvln };
static const struct vsghnouiwbyk qnarboxjrxzn = { {0, 1, 0, 0, 0, 1, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, qlbsybjbuuwq }, { 0x00, 2, 0x07, 0, ajxmlmqzwxcy }, { 0, 0, 0xf0, 4, buuehtaguyng }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, mbtdrqfkrhlf, NULL };
static const struct vsghnouiwbyk vxdzvmepjvvw = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, hzaxbgzfvbgn }, { 0, 1, 0x0F, 0, sjcyohrqpoaq }, { 0, 1, 0xf0, 4, hydxpacucott }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 7, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, piayrwdcoabm, NULL };
static const struct vsghnouiwbyk belikbrskevt = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 286, {6, 64, 64, 152}, { 3, 6, 0xfe, 1, dirmsniyzxmk }, { 3, 5, 0x70, 4, nzrkfuvfonaq }, { 3, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL }, &nhfcnuxssqdy, {.xdvjpfttnymn.yeltdjdwiegk = {{3, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, tqokiavwcgfc, &gxwjutmejxvu };
static const struct vsghnouiwbyk vdvubiodajlu = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 4, 0x0f, 0, qlbsybjbuuwq }, { 0, 1, 0x70, 4, buylqkkswbpc }, { 0, 5, 0xe0, 5, exghimrmmgkb }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0xc0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, ybjlgbokpeap, NULL };
static const struct vsghnouiwbyk bujdavsupzey = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 96, {32, 32, 32, 0}, { 0, 2, 0xf0, 4, rnzkhkybayht }, { 0xC0, 3, 0x0f, 0, wtkljughxyhz }, { 0x40, 4, 0x0f, 0, tgvozcdkwizi }, { 0, 4, 0xff, 0, dyotlvvkqnpr }, &holbhphlckyo, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, pjyjlubiskul, NULL };
static const struct vsghnouiwbyk bzpgxccuygdj = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x0f, 0, qlbsybjbuuwq }, { 0, 9, 0xe0, 5, hsuvxgtgltjj }, { 0, 7, 0x60, 5, ygdgsrknfpiy }, { 0, 5, 0x1f, 0, hflaumdbxlvi }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 9}, 7, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0} }, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk xgapiyfdyqej = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq }, { 0, 5, 0x70, 4, dhxclxrtlauf }, { 0, 4, 0x07, 0, uyyrvcoowruy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 9}, 0, 0x03}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0} }, byrdqdaczwxz, NULL };
static const struct vsghnouiwbyk ezugptpfzbsu = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 72, {72, 0, 0, 0}, { 0, 6, 0xff, 0, hzaxbgzfvbgn }, { 0, 1, 0x0F, 0, sjcyohrqpoaq }, { 0, 1, 0xf0, 4, tdwegvcedrpe }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 9}, 7, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0} }, olhrfncspuea, NULL };
static const struct vsghnouiwbyk amwxhlmwgweb = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 1, 0x0f, 0, huxsncyaliwc }, { 0x80, 1, 0xc0, 6, ewocvipkuzaw }, { 0, 1, 0x30, 4, ygdgsrknfpiy }, { 0, 4, 0x02, 1, pvaqlkvrylaf }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0} }, byrdqdaczwxz, NULL };
static const struct vsghnouiwbyk usjjkfzdtivx = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 128, {72, 56, 0, 0}, { 0, 6, 0xFF, 0, lrpkzrzobwqs }, { 0, 1, 0x0f, 0, sjcyohrqpoaq }, { 0, 1, 0xf0, 4, hydxpacucott }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 9}, 7, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0} }, butuufvlfofh, NULL };
static const struct vsghnouiwbyk tinobgdjddsw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 2, 0xf0, 4, qlbsybjbuuwq }, { 0xC0, 3, 0x0f, 0, kmaatknfqqxv }, { 0x40, 4, 0x0f, 0, tgvozcdkwizi }, { 0, 4, 0xff, 0, dyotlvvkqnpr }, &zlpsuvgjiqwv, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 8}, 2, 0x85}, .xdvjpfttnymn.umavhyptrjjy = {{0,8},3,0x16}}, engafuusnyoi, NULL };
static const struct vsghnouiwbyk fychrhgzshew = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xff, 0, hzaxbgzfvbgn }, { 0, 2, 0x07, 0, vdgjgcoiublr }, { 0, 2, 0x60, 5, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 9}, 1, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0} }, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk xprioipfdfus = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, qlbsybjbuuwq }, { 0, 6, 0x70, 4, hsuvxgtgltjj }, { 0, 6, 0x03, 0, ybuezpmusfwy }, { 0, 0, 0, 0, NULL }, &znsmeszcajgq, {.xdvjpfttnymn.yeltdjdwiegk={{0, 9}, 1, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0} }, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk rfnrflwnuqav = { {1, 0, 0, 1, 1, 0, 0}, 0x35, 100, {100, 0, 0, 0}, { 0, 3, 0x0F, 0, qlbsybjbuuwq }, { 0, 4, 0x07, 0, jwphqmnoiuwo }, { 0, 4, 0x70, 4, aqptxectdvef }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk ruwlldvyquwu = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x0f, 0, qlbsybjbuuwq }, { 0, 9, 0xe0, 5, hsuvxgtgltjj }, { 0, 7, 0xe0, 5, ygdgsrknfpiy }, { 0, 5, 0xff, 0, hflaumdbxlvi }, &dldneguofhfg, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 7, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, aszgewaorkyw, NULL };
static const struct vsghnouiwbyk rhfhkstmsxtp = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 192, {16, 80, 16, 80}, { 1, 0, 0xf0, 4, qlbsybjbuuwq }, { 1, 0, 0x07, 0, sohkunnzjygb }, { 1, 8, 0xf0, 4, riybiayodery }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 8}, 0, 0x82}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, azjugvbsdsqp, NULL };
static const struct fehyfyrgmlkh snjhobcqrytl = {NULL, &rhfhkstmsxtp, 1, 95};
static const struct vsghnouiwbyk ianducitsrqp = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 96, {16, 80, 0, 0}, { 1, 0, 0xf0, 4, qlbsybjbuuwq }, { 1, 0, 0x07, 0, sohkunnzjygb }, { 1, 8, 0xf0, 4, riybiayodery }, { 0x80, 0, 0, 0, NULL }, &eyvjsnhgibgz, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 8}, 0, 0x82}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, ewcwtwtnjumd, NULL };
static const struct vsghnouiwbyk nonrnqmxwbmk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, dvdpdyuxhulp}, { 0, 6, 0x0f, 0, qzrdkksygiln}, { 0, 8, 0x07, 0, xknpcbptryfb}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk kxpowzotobxt = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 136, {136, 0, 0, 0}, { 0, 0x46, 0xFF, 0, nuyihfymrlxy }, { 0x0, 5, 0xf0, 4, txsbffnaanwl }, { 0, 5, 0x0f, 0, obqdvlxymdam }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 8, 0x20}, .xdvjpfttnymn.umavhyptrjjy = {{0,0}, 0, 0}}, iprctvkigumk, NULL };
static const struct vsghnouiwbyk dhjcyvqfsjfv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xf0, 4, qlbsybjbuuwq }, { 0, 3, 0x07, 0, einaxguqxgdv }, { 0, 2, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,8}, 2, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk dckwpjtrcquf = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, qlbsybjbuuwq }, { 0, 0, 0x8C, 2, psyzdexniwbw }, { 0, 0, 0x03, 0, souulsuvkqvp }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,8}, 1, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, lenaojpypmgf, NULL };
static const struct vsghnouiwbyk ugrwnkglmliy = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 47, {47, 0, 0, 0}, { 0, 5, 0x1F, 0, duzqslhlvrbd }, { 0, 2, 0x0C, 2, jzebnhioprnt }, { 0, 2, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,9}, 1, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk szcgozpgdhlj = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 30, {7, 8, 7, 8}, { 1, 0, 0x0F, 0, jxwvazqfgoxj }, { 0, 0, 0x07, 0, gboajlxtrvem }, { 0, 0, 0x70, 4, plbsqfqwtdxy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,8}, 0, 0x35}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, ygcxahquzvij, NULL };
static const struct vsghnouiwbyk gfzhwwyanuvr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x0F, 0, qlbsybjbuuwq }, { 0, 1, 0x30, 4, eoaliifvrjnc }, { 0, 1, 0xc0, 6, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,8}, 1, 0x0c}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk dphdfbfzweey = { {1, 1, 1, 0, 0, 0, 0}, 0x32, 192, {48, 48, 48, 48}, { 0, 4, 0xf0, 4, mmaikokpzmiv }, { 0x00, 4, 0x0c, 2, rwxhlwtqcuxy }, { 0x80, 2, 0xe0, 5, rxjkcgzrlsjg }, { 2, 2, 0xff, 0, lrypgvboynfb }, &jtfyeafstjuo, {.jylyhhlxgchq = (const bc7215DataVarPkt_t*)abgtrwyfidmh}, puyhqnzygnrs, NULL };
static const struct vsghnouiwbyk avpnqbczfhid = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 368, {64, 152, 152, 0}, { 1, 6, 0x1e, 1, qlbsybjbuuwq }, { 1, 5, 0x70, 4, nzrkfuvfonaq }, { 1, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, etzpkrbcxmgi, NULL };
static const struct vsghnouiwbyk adjhkkqsdmqh = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 40, {32, 8, 0, 0}, { 0, 2, 0x0F, 0, qlbsybjbuuwq }, { 0, 1, 0x07, 0, hsuvxgtgltjj }, { 0, 1, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,3}, 1, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, cxxqpwnfospn, NULL };
static const struct vsghnouiwbyk cdkxnbhpkwur = { {0, 1, 0, 0, 0, 1, 0}, 0x36, 168, {16, 96,56, 0}, { 1, 1, 0xf0, 4, qlbsybjbuuwq }, { 1, 1, 0x07, 0, einaxguqxgdv }, { 1, 0, 0x03, 0, ygdgsrknfpiy }, { 2, 1, 0xff, 0, bxstpkifthlt }, &umwiydxghooo, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 3}, 0, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dvlmbpsinqoo, &snhznrtscwoh };
static const struct vsghnouiwbyk yqoylwgfvree = { {0, 0, 0, 0, 0, 1, 0}, 0x36, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, hzaxbgzfvbgn }, { 0, 1, 0x0F, 0, sjcyohrqpoaq }, { 0, 1, 0xf0, 4, hydxpacucott }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 7, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, olhrfncspuea, &gxanzhyuafjw };
static const struct vsghnouiwbyk htmqewjjuchg = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 97, {96, 1, 0, 0}, { 0, 1, 0x0F, 0, qlbsybjbuuwq }, { 0, 4, 0x70, 4, hlwjchgwhrxt }, { 0, 4, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 8}, 5, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk quusmcsmbrdg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, huxsncyaliwc }, { 0, 0, 0x07, 0, fumlhnuvtjti }, { 0, 0, 0xf0, 4, riybiayodery }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, lenaojpypmgf, NULL };
static const struct vsghnouiwbyk potqaxxhcsxu = { {0, 0, 0, 0, 0, 1, 0}, 0x36, 140, {140, 0, 0, 0}, { 0, 16, 0xff, 0, hzaxbgzfvbgn }, { 0, 15, 0x70, 4, sjcyohrqpoaq }, { 0, 15, 0x0f, 0, hydxpacucott }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,3}, 14, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, cfwgnoydaeun, NULL };
static const struct vsghnouiwbyk sgmoovzwkufu = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 5, 0xf0, 4, huxsncyaliwc }, { 0, 4, 0x70, 4, uhvnpakabflt }, { 0, 4, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,9}, 4, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, fmqkqpymqyvi, NULL };
static const struct vsghnouiwbyk ebevanqcipbu = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {31, 31, 0, 0}, { 0, 3, 0x1e, 1, duzqslhlvrbd }, { 0, 0, 0xf0, 4, gzwyyudcsgwr }, { 0, 1, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 1, 0x20}}, fqgiigpemcaz, NULL };
static const struct vsghnouiwbyk wvybpsgtheih = { {0, 1, 0, 1, 1, 1, 0}, 0x36, 262, {64, 64, 0, 0}, { 0, 6, 0xFF, 0, hzaxbgzfvbgn }, { 0, 1, 0x0F, 0, sjcyohrqpoaq }, { 0, 1, 0xf0, 4, hydxpacucott }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 7, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{1, 3}, 2, 0x04}}, tmzqoiuybvgp, &yppgniqoksfm };
static const struct vsghnouiwbyk hiluulshukkt = { {0, 1, 0, 0, 0, 0, 0}, 0x35, 201, {35,67,67,32}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0, 0, 0x07, 0, hsuvxgtgltjj }, { 0x82, 2, 0x70, 4, vsldpvefbakr }, { 0, 0, 0x30, 4, dvtgclyxpwol }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, nfuqjxctiyow, NULL };
static const struct vsghnouiwbyk bbmxprqsumyr = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 2, 0x7f, 0, mnqdymgkrwjk }, { 0, 1, 0x70, 4, mjzkesqcmxsp }, { 0, 7, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.jylyhhlxgchq=(const bc7215DataVarPkt_t*)qlhchaocgvwk}, trsclbhfsdgr, NULL };
static const struct vsghnouiwbyk urfurxwqooqq = { {0, 1, 0, 0, 0, 0, 1}, 0x34, 95, {22, 60, 8, 5}, { 1, 0, 0x1f, 0, nemjsunvswft }, { 0, 2, 0x38, 3, mtqttagzkyvk }, { 1, 0, 0x60, 5, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &ipinhabavepz, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 6, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, stucxxyamdmv, NULL };
static const struct vsghnouiwbyk xkdlcjkwyutn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 2, 0x1f, 0, nemjsunvswft }, { 0, 1, 0xE0, 5, ddrkrcyvihjd }, { 0, 2, 0xe0, 5, ioyqosfwejrk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 3, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk tunbaebrcugn = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 72, {16, 56, 0, 0}, { 1, 1, 0x0f, 0, aekximikujqn }, { 1, 0, 0x07, 0, gjckeliagtvm }, { 1, 0, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dyoerhuugkim, &kpmkxpudvpbo };
static const struct vsghnouiwbyk qyiaaavqpcrj = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0xF0, 4, qlbsybjbuuwq }, { 0, 6, 0x07, 0, gjckeliagtvm }, { 0, 6, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &parpdhefvtab };
static const struct vsghnouiwbyk nrzxnreoqfes = { {1, 1, 0, 0, 0, 0, 0}, 0x32, 256, {72, 72, 56, 56}, { 0, 5, 0xF0, 4, pqzbdwgjzgjg }, { 0, 6, 0x07, 0, vdgjgcoiublr }, { 0, 6, 0xe0, 5, jeqgpekhirgy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 6, 0x07}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, xqxlikpvrrsq, NULL };
static const struct vsghnouiwbyk rmwdswfttmbu = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 2, 0x0f, 0, pqzbdwgjzgjg }, { 0, 1, 0x07, 0, mpbrctckhasl }, { 0, 1, 0x18, 3, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, aduwdhgzncqz, NULL };
static const struct vsghnouiwbyk yqsapwqtglab = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0x0f, 0, qlbsybjbuuwq }, { 0, 2, 0x07, 0, hsuvxgtgltjj }, { 0, 2, 0x70, 4, vsldpvefbakr }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, qllnjqsepdux, NULL };
static const struct vsghnouiwbyk hmmzijkzbnxa = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 3, 0x0f, 0, qlbsybjbuuwq }, { 0, 2, 0x07, 0, hsuvxgtgltjj }, { 0, 2, 0x70, 4, vsldpvefbakr }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, lmkxtcrveiui, NULL };
static const struct vsghnouiwbyk qcgrsxpxneke = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x0f, 0, pqzbdwgjzgjg }, { 0, 6, 0x07, 0, lcfcdrxiqyzz }, { 0, 6, 0x70, 4, qzwqicrgdjvb }, { 0, 5, 0x30, 4, bwmvykmymvdg }, &xxklregglwyz, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, zvwjvnoedyko, NULL };
static const struct vsghnouiwbyk vhahdjtyhnev = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x1e, 1, xgmfromrdrwl }, { 0, 6, 0x0f, 0, saueijuhxhjx }, { 0, 6, 0x70, 4, qzwqicrgdjvb }, { 0, 5, 0x30, 4, bwmvykmymvdg }, &xxklregglwyz, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, zvwjvnoedyko, &xdcmbuypvmwr };
static const struct vsghnouiwbyk wpdkfzbiblvr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x0f, 0, huxsncyaliwc }, { 0, 6, 0x07, 0, lcfcdrxiqyzz }, { 0, 6, 0x70, 4, qzwqicrgdjvb }, { 0, 5, 0x30, 4, bwmvykmymvdg }, &ujqhykhpmude, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, zvwjvnoedyko, NULL };
static const struct vsghnouiwbyk ddzjxyrgrftr = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 96, {32, 32, 32, 0}, { 1, 1, 0xf0, 4, pqzbdwgjzgjg }, { 1, 1, 0x07, 0, lcfcdrxiqyzz }, { 1, 2, 0x70, 4, vsldpvefbakr }, { 1, 3, 0x03, 0, bwmvykmymvdg }, &lsxrgzunwiuv, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, xbqqeploqxoa, NULL };
static const struct vsghnouiwbyk vsdfyxzyqdfv = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 1, 0xF0, 4, ujhihmyhohwg }, { 0, 0, 0xe0, 5, dcxgciynobhy }, { 0, 0, 0x0c, 2, odzevozycpja }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0,8}, 0, 0x00}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, byrdqdaczwxz, NULL };
static const struct vsghnouiwbyk dsftotuwiohl = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq }, { 0, 3, 0x0e, 1, eidniawnhpyq }, { 0, 6, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 3, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk pekcqfxtulwr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, auwyugwmwlso }, { 0, 6, 0x0f, 0, niaotlqdftsv }, { 0, 8, 0x07, 0, xknpcbptryfb }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, cxxqpwnfospn, NULL };
static const struct vsghnouiwbyk ihyhevxycowr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, hzaxbgzfvbgn }, { 0, 6, 0x0f, 0, niaotlqdftsv }, { 0, 8, 0x07, 0, xknpcbptryfb }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk iywngrxojtws = { {0, 1, 0, 0, 0, 1, 0}, 0x30, 64, {32, 32, 0, 0}, { 0, 0, 0x0f, 0, huxsncyaliwc }, { 0, 2, 0x07, 0, koatbgekibjo }, { 0, 0, 0xf0, 4, tdwegvcedrpe }, { 0, 0, 0, 0, NULL }, &ocwpowzplqnb, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, amkaibhhhfsc, NULL };
static const struct vsghnouiwbyk asmgemmtkzbl = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 2, 0xf0, 4, huxsncyaliwc }, { 0, 3, 0x07, 0, qqnypqpywrvq }, { 0, 3, 0x70, 4, aglvlpkugvof }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 8}, 2, 0xb8}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, lgosiqlfwtjf, NULL };
static const struct vsghnouiwbyk frgkgovuctak = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq }, { 0, 2, 0xe0, 5, hsuvxgtgltjj }, { 0, 5, 0x60, 5, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, irmhhvnxqwbx, NULL };
static const struct vsghnouiwbyk gcmchtjnfppj = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 312, {160, 152, 0, 0}, { 1, 6, 0xfe, 1, dirmsniyzxmk }, { 1, 5, 0x70, 4, nzrkfuvfonaq }, { 1, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL }, &mdxfijtgnbep, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 6, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{1, 9}, 5, 0x01}}, vixgnerqasdw, &xzgukzrwqvln };
static const struct vsghnouiwbyk yhdblojcgnva = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 160, {56, 104, 0, 0}, { 1, 9, 0x3E, 1, atzscyghbqee }, { 1, 5, 0x70, 4, cmvjkmxfoogt }, { 1, 10, 0x0f, 0, sodnmplfotvu }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dyoerhuugkim, NULL };
static const struct vsghnouiwbyk qrwbqaqglhxy = { {0, 1, 0, 0, 0, 0, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, huxsncyaliwc }, { 0x00, 2, 0x07, 0, ltlemtyukwcf }, { 0, 0, 0xf0, 4, buuehtaguyng }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, mbtdrqfkrhlf, NULL };
static const struct vsghnouiwbyk czhnihunkwan = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0xff, 0, mcmwdzsspsij }, { 0x00, 0, 0x07, 0, hsuvxgtgltjj }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &rbmxpyedhqsi, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk bxwfmlvnqwnr = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 72, {72, 0, 0, 0}, { 0, 6, 0xff, 0, lrpkzrzobwqs }, { 0, 1, 0x0F, 0, sjcyohrqpoaq }, { 0, 1, 0xf0, 4, hydxpacucott }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 9}, 7, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0} }, olhrfncspuea, NULL };
static const struct vsghnouiwbyk fsskyqkxdhcs = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x1f, 0, nemjsunvswft }, { 0x80, 3, 0x30, 4, bbdoduitrwbi }, { 0, 3, 0x03, 0, gwmvscjwshzk }, { 0, 2, 0xff, 0, mznzdziymvik }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)abrviblocjbf }, trsclbhfsdgr, NULL };
static const struct vsghnouiwbyk unlmpectkiei = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 1, 0x1f, 0, nemjsunvswft }, { 0x80, 3, 0x30, 4, bbdoduitrwbi }, { 0, 3, 0x03, 0, gwmvscjwshzk }, { 0, 2, 0xff, 0, bzkuzronqwts }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)spqsxntkdvjb }, trsclbhfsdgr, NULL };
static const struct vsghnouiwbyk tyhxfbrsvtat = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 4, 0x0f, 0, zmuhmziggshb }, { 0, 4, 0x30, 4, xramcvgpilnw }, { 0, 2, 0x07, 0, mctpbidjvrsb }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 9}, 4, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk antbjenlltbx = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0x0f, 0, duzqslhlvrbd }, { 0, 4, 0x18, 3, cuyzhcvurjqp }, { 0, 4, 0x07, 0, zazdvdrlgoxw }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 3}, 4, 0x20}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk sbynchcbxvzz = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0xf0, 4, duzqslhlvrbd }, { 0, 2, 0x07, 0, umjxfsvzcsro }, { 0, 0, 0x18, 3, watlqftdktqz }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk tpoussptlpir = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0xf0, 4, duzqslhlvrbd }, { 0, 2, 0x03, 0, cuyzhcvurjqp }, { 0, 0, 0x18, 3, watlqftdktqz }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk={{0, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk bjyacowgclrs = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 4, 0xf0, 4, duzqslhlvrbd }, { 0x0, 4, 0x07, 0, bafqaozlnera }, { 0, 2, 0x70, 4, zazdvdrlgoxw }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0,3},4,0x08}}, vjmyvdqynrdc, NULL };
static const struct vsghnouiwbyk xjhuruxmsxur = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, pqzbdwgjzgjg }, { 0x0, 2, 0x70, 4, nbgcalmcrydn }, { 0, 1, 0x70, 4, jiytyamonchm }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dsuxtremdabv, NULL };
static const struct vsghnouiwbyk ahqnxetdjfhw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 152, {152, 0, 0, 0}, { 0, 6, 0x3e, 1, nemjsunvswft }, { 0x80, 5, 0xe0, 5, gboajlxtrvem }, { 0, 5, 0x0c, 2, gwmvscjwshzk }, { 0, 6, 0x80, 7, pvaqlkvrylaf }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 9}, 8, 0x20}}, vqivsbeaooll, &zeshamptsbtz };
static const struct vsghnouiwbyk hwszgljvdrlq = { {0, 1, 1, 0, 0, 0, 0}, 0x37, 113, {12, 45, 12, 44}, { 3, 3, 0x0f, 0, qlbsybjbuuwq }, { 3, 4, 0x07, 0, hsuvxgtgltjj }, { 3, 3, 0xe0, 5, ylmeljrhbupr }, { 0, 0, 0, 0, NULL }, &uwamrtxlewym, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)tmcuunujvvxt}, qoxwndjnfccy, NULL };
static const struct vsghnouiwbyk cwbxuyltciee = { {1, 1, 1, 0 , 0, 0, 0}, 0x36, 160, {80, 80, 0, 0}, { 0, 5, 0xf0, 4, pqzbdwgjzgjg}, { 0, 6, 0x07, 0, vdgjgcoiublr}, { 0, 6, 0xC0, 6, jstalkdbnehx }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)owujvsewldzf}, fwastflmujzt, NULL };
static const struct vsghnouiwbyk yefbhjuaaukj = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 3, 0x0f, 0, qlbsybjbuuwq }, { 0, 1, 0x0f, 0, ujgogupnevgb }, { 0, 1, 0xe0, 5, irftdmkwcmwl }, { 0, 6, 0x1f, 0, arrgrcqyizqk }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk gwjuvxfrhkda = { {0, 1, 1, 0, 0, 0, 0}, 0x32, 192, {96, 48, 48, 0}, { 1, 4, 0x0f, 0, zmuhmziggshb }, { 1, 4, 0x30, 4, xramcvgpilnw }, { 1, 2, 0x07, 0, mctpbidjvrsb }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.jylyhhlxgchq = (const bc7215DataVarPkt_t*)rfvsrlawowjl}, snczkqcpgjfu, NULL };
static const struct vsghnouiwbyk pbwzfbkdvpdh = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 161, {56, 104, 1, 0}, { 1, 9, 0xFE, 1, xgmfromrdrwl }, { 1, 5, 0x70, 4, cmvjkmxfoogt }, { 1, 10, 0x0f, 0, sodnmplfotvu }, { 0, 0, 0, 0, NULL}, &nxrdhuyhzxrv, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dyoerhuugkim, NULL };
static const struct vsghnouiwbyk tnmzrgshvqop = { {1, 0, 0, 0, 0, 0, 0}, 0x36, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq }, { 0x0, 5, 0x70, 4, ybuezpmusfwy }, { 0, 4, 0x07, 0, eobqxjqhbanf }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x03}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, byrdqdaczwxz, NULL };
static const struct vsghnouiwbyk qehnqekdxhfv = { {1, 0, 0, 0, 0, 0, 0}, 0x36, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq }, { 0x40, 5, 0xf0, 4, ueqljpyepgwu }, { 0, 5, 0xf0, 4, jrumdzqovxoi }, { 0, 0, 0, 0, NULL }, &xhvvxndvofwx, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x03}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 0, 0x80}}, byrdqdaczwxz, NULL };
static const struct vsghnouiwbyk zpzfevkcpjud = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq }, { 0x40, 5, 0xf0, 4, ueqljpyepgwu }, { 0, 5, 0xf0, 4, jrumdzqovxoi }, { 0, 0, 0, 0, NULL }, &xhvvxndvofwx, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x03}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 0, 0x80}}, byrdqdaczwxz, NULL };
static const struct fehyfyrgmlkh negidwahpefw = {NULL, &yeobnxyjvwij, 2, 165};
static const struct vsghnouiwbyk igqwlbaumthx = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0x0f, 0, imegbmhoswpz }, { 0x00, 1, 0x30, 4, zoxbzpgkrild }, { 0, 1, 0xc0, 6, bqkwjhxmdzlf }, { 0x80, 2, 0x0f, 0, wowphqlodpqt }, &emvapmianrew, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0,9},0,0x10}}, gcpbulrrerdq, NULL };
static const struct fehyfyrgmlkh cymtnhfkrgtc = {NULL, &hiwirhjbknsp, 2, 165};
static const struct vsghnouiwbyk grxqbegngbcc = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0x0f, 0, mscxujnqnuhc }, { 0x00, 1, 0x30, 4, zoxbzpgkrild }, { 0, 1, 0xc0, 6, bqkwjhxmdzlf }, { 0x80, 2, 0x0f, 0, bitfqvjznjnl }, &hiloxabfxord, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0,9},0,0x10}}, gcpbulrrerdq, NULL };
static const struct fehyfyrgmlkh rvwpmredthnx = {NULL, &pkozyrktbizw, 2, 165};
static const struct vsghnouiwbyk semrpkmgzkes = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0x0f, 0, mscxujnqnuhc }, { 0x00, 1, 0x30, 4, zoxbzpgkrild }, { 0, 1, 0xc0, 6, bqkwjhxmdzlf }, { 0x80, 2, 0x0f, 0, wowphqlodpqt }, &rkaabhrcosee, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0,9},0,0x10}}, gcpbulrrerdq, NULL };
static const struct fehyfyrgmlkh bfynarpwhgxo = {NULL, &fkblteeqdvec, 2, 165};
static const struct vsghnouiwbyk byypyoadghjd = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0x0f, 0, yqfsdnalmyna }, { 0x00, 1, 0x30, 4, zoxbzpgkrild }, { 0, 1, 0xc0, 6, bqkwjhxmdzlf }, { 0x80, 2, 0x0f, 0, bitfqvjznjnl }, &kwukecrusnya, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0,9},0,0x10}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk rrcjryshsgce = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, sroodvqdigbh }, { 0xc0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, mjrcpzynekqf, NULL };
static const struct vsghnouiwbyk unvnzhegbnrb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, stgqkuoucjmg }, { 0xc0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, lijheqifumjh, NULL };
static const struct vsghnouiwbyk vzyoelzqdgzg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x0f, 0, qlbsybjbuuwq }, { 0, 1, 0xF0, 4, lnfwnedlkogu }, { 0, 1, 0x0F, 0, tdwegvcedrpe }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0X80}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk zkkvabkzxgem = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 2, 0xf0, 4, duzqslhlvrbd }, { 1, 2, 0x07, 0, bafqaozlnera }, { 1, 4, 0xe0, 5, idmdsvmdrdfb }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 3}, 2, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, wiuiioibmfwg, NULL };
static const struct vsghnouiwbyk nfjszktunhfg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, rnzkhkybayht }, { 0, 0, 0x07, 0, hsuvxgtgltjj}, { 0, 0, 0x30, 4, tgvozcdkwizi}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk spugopwtbinl = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, huxsncyaliwc }, { 0, 0, 0x07, 0, hsuvxgtgltjj}, { 0, 0, 0x30, 4, tgvozcdkwizi}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk iymxxfzgmije = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 144, {16, 56, 16, 56}, { 1, 3, 0xf0, 4, qlbsybjbuuwq }, { 1, 0, 0xF0, 4, xwsylmhoratf }, { 1, 1, 0x30, 4, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0Xf0}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, hzekdkbdrpvm, NULL };
static const struct vsghnouiwbyk ynfoubjzgmxd = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 160, {16, 64, 16, 64}, { 1, 3, 0xf0, 4, qlbsybjbuuwq }, { 1, 0, 0xF0, 4, xwsylmhoratf }, { 1, 1, 0x30, 4, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0Xf0}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, hzekdkbdrpvm, NULL };
static const struct vsghnouiwbyk rojtzzhagiut = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 48, {24, 24, 0, 0}, { 0, 2, 0x0f, 0, rnzkhkybayht }, { 0, 2, 0x70, 4, nbgcalmcrydn }, { 0, 1, 0x70, 4, aqptxectdvef }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 8}, 2, 0xa7}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, dsuxtremdabv, NULL };
static const struct vsghnouiwbyk rubegqvxrpww = { {0, 1, 0, 0, 0, 1, 0}, 0x21, 102, {34, 34, 34, 0}, { 0, 1, 0x1E, 1, huxsncyaliwc }, { 0, 0, 0x70, 4, hiqcqegacvct }, { 0, 0, 0x0c, 2, watlqftdktqz }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 8}, 0, 0x9c}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, ydnuhcvrirma, NULL };
static const struct vsghnouiwbyk dvrsczfkecqr = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 100, {50, 50, 0, 0}, { 0, 3, 0x78, 3, duzqslhlvrbd }, { 0x80, 0, 0x0c, 2, qkzbyzcluece }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0, 4, 0xff, 0, lmcndmewtobi }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 9}, 5, 0x30}}, fqgiigpemcaz, NULL };
static const struct vsghnouiwbyk yjxtcmaacuig = { {0, 0, 0, 0, 0, 1, 0}, 0x30, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, hzaxbgzfvbgn }, { 0, 1, 0x0F, 0, sjcyohrqpoaq }, { 0, 1, 0xf0, 4, hydxpacucott }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 7, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, olhrfncspuea, &gxanzhyuafjw };
static const struct vsghnouiwbyk zgbyxgpkyebe = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, auwyugwmwlso}, { 0, 6, 0x0f, 0, niaotlqdftsv}, { 0, 8, 0x07, 0, wlrehuclbzxu }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk abcafvsejaij = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 17, {16, 1, 0, 0}, { 0, 1, 0xF8, 3, tkgjxmqmrafm }, { 0, 1, 0x07, 0, hsuvxgtgltjj }, { 0, 0, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 0, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, jhhgzesmesgc, NULL };
static const struct vsghnouiwbyk ipipwyqtpaaj = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 5, 0x0f, 0, huxsncyaliwc }, { 0, 4, 0x70, 4, hsuvxgtgltjj }, { 0, 4, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 3, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, ukusubqnfddc, NULL };
static const struct vsghnouiwbyk paezwzulvdgx = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 2, 0xf0, 4, rnzkhkybayht }, { 0, 3, 0x07, 0, eidniawnhpyq }, { 0, 3, 0x70, 4, aglvlpkugvof }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, snxzripxaitf, NULL };
static const struct vsghnouiwbyk epyoqnvgghdy = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, qlbsybjbuuwq}, { 0, 0, 0x07, 0, hsuvxgtgltjj}, { 0, 3, 0x03, 0, tgvozcdkwizi}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk mbxiqyepxsjn = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 176, {112, 64, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0, 7, 0xe0, 5, vfbfuutoazdp }, { 0, 5, 0xe0, 5, vukdbvtfigfk }, { 0, 12, 0x07, 0, tfnbefmjojvh }, &zmhblajtiiim, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vixgnerqasdw, NULL };
static const struct vsghnouiwbyk tpomjhykpjuo = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 56, {8, 48, 0, 0}, { 1, 2, 0x0f, 0, qlbsybjbuuwq }, { 1, 0, 0x0f, 0, tajyfdalqtrk }, { 1, 1, 0x07, 0, owzoglwzsxda }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, yfkkffuyjdjc, NULL };
static const struct vsghnouiwbyk fcgssliofujs = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 56, {8, 48, 0, 0}, { 1, 2, 0x7E, 1, rzgdiuvzpbzk }, { 1, 0, 0x0f, 0, tajyfdalqtrk }, { 1, 1, 0x07, 0, owzoglwzsxda }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, yfkkffuyjdjc, &euxkwzlzuwaf };
static const struct vsghnouiwbyk ctgmvkldoisb = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, aekximikujqn }, { 1, 1, 0x07, 0, einaxguqxgdv }, { 1, 0, 0x03, 0, ygdgsrknfpiy }, { 2, 1, 0xff, 0, bhpujprhbbzz }, &ygodycsenfrr, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dvlmbpsinqoo, &ymzofyqomcwt };
static const struct vsghnouiwbyk vkkvnwdbdxmk = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, qlbsybjbuuwq }, { 0x0, 5, 0x70, 4, ybuezpmusfwy }, { 0, 4, 0x07, 0, aqptxectdvef }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, byrdqdaczwxz, NULL };
static const struct vsghnouiwbyk wfmzshwqbivk = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfe, 1, dirmsniyzxmk }, { 3, 5, 0x70, 4, nzrkfuvfonaq }, { 3, 8, 0xf0, 4, klltwbstguam }, { 0, 0, 0, 0, NULL }, &nxrdhuyhzxrv, {.xdvjpfttnymn.yeltdjdwiegk = {{3, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{3, 9}, 9, 0x0f}}, tqokiavwcgfc, &bnqhrpudkhrd };
static const struct vsghnouiwbyk ovmlwnlrsevm = { {0, 1, 0, 0 ,0, 0, 0}, 0x36, 216, {64, 152, 0, 0}, { 1, 6, 0xff, 0, jvyasvocpwas }, { 1, 5, 0x70, 4, cmvjkmxfoogt }, { 1, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL}, &rnlrefsedaas, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, vixgnerqasdw, NULL };
static const struct vsghnouiwbyk bzjfuxzokxxj = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 317, {5, 160, 152, 0}, { 2, 6, 0xfe, 1, dirmsniyzxmk }, { 2, 5, 0x70, 4, nzrkfuvfonaq }, { 2, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL }, &fykqxdnfxwad, {.xdvjpfttnymn.yeltdjdwiegk = {{2, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{1, 3}, 12, 0x80}}, qyqoaflwwyom, NULL };
static const struct vsghnouiwbyk zlgllbxgjtyv = { {0, 1, 0, 0, 0, 1, 0}, 0x30, 128, {64, 64, 0, 0}, { 0, 6, 0xff, 0, hzaxbgzfvbgn }, { 0, 1, 0x0f, 0, sjcyohrqpoaq }, { 0, 1, 0xf0, 4, hydxpacucott }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 7, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, olhrfncspuea, &gxanzhyuafjw };
static const struct vsghnouiwbyk yxnnabussnqb = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 424, {24, 400, 0, 0}, { 1, 10, 0x3c, 2, qlbsybjbuuwq }, { 1, 22, 0x07, 0, hhhswelrvjuh }, { 1, 22, 0x70, 4, xkbkyujymdhn }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 24, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, wiuiioibmfwg, NULL };
static const struct vsghnouiwbyk vbzncqmbrymb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0xff, 0, hzaxbgzfvbgn }, { 0, 0, 0x07, 0, ezdvwkrfawmx }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0x80, 0, 0, 0, NULL }, &ancqczfcjgbu, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0,8},1,0x16}}, gcpbulrrerdq, NULL };
static const struct vsghnouiwbyk tiaehomwqyan = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 64, {20, 44, 0, 0}, { 1, 0, 0xf0, 4, qlbsybjbuuwq }, { 1, 0, 0x03, 0, lkbvugtuxcmh }, { 1, 0, 0x0c, 2, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 2, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, ycpdjrrnteir, NULL };
static const struct vsghnouiwbyk gklxmouxhpyd = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x0f, 0, pqzbdwgjzgjg }, { 0, 2, 0x0e, 1, fumlhnuvtjti }, { 0, 1, 0x60, 5, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &lsawdfksfpqm, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk tptgodlwulpv = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 192, {32, 160, 0, 0}, { 1, 6, 0x1e, 1, qlbsybjbuuwq }, { 1, 4, 0x07, 0, azkyukdfmqqr }, { 1, 8, 0x07, 0, qtpbyvcfejdx }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 2, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, wiuiioibmfwg, NULL };
static const struct vsghnouiwbyk yupaowqbbyxt = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 80, {80, 0, 0, 0}, { 0, 3, 0x0f, 0, qlbsybjbuuwq }, { 0, 1, 0x0f, 0, ujgogupnevgb }, { 0, 1, 0xe0, 5, irftdmkwcmwl }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, cxxqpwnfospn, NULL };
static const struct vsghnouiwbyk qeaqrsqdkjpk = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 56, {56, 0, 0, 0}, { 0, 2, 0x1f, 0, sjmbrhgdfrrn }, { 0, 1, 0x03, 0, smlahnhsfqyk }, { 0, 1, 0x38, 3, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &lyldgksdaetb };
static const struct vsghnouiwbyk apjkjngzznni = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 120, {56, 64, 0, 0}, { 1, 1, 0xF0, 4, qlbsybjbuuwq }, { 1, 2, 0x07, 0, hsuvxgtgltjj }, { 1, 3, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)ciufpmfcmooy}, yfkkffuyjdjc, NULL };
static const struct vsghnouiwbyk jqxvxuicdqvd = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 56, {12, 44, 0, 0}, { 1, 3, 0x0f, 0, qlbsybjbuuwq }, { 1, 4, 0x07, 0, hsuvxgtgltjj }, { 1, 3, 0xe0, 5, ylmeljrhbupr }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x03}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, bcvrjesyhbss, NULL };
static const struct vsghnouiwbyk vmdcinvqgjjl = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 140, {140, 0, 0, 0}, { 0, 16, 0xFF, 0, hzaxbgzfvbgn }, { 0, 15, 0xf0, 4, sjcyohrqpoaq }, { 0, 15, 0x0f, 0, hydxpacucott }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 14, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, cfwgnoydaeun, NULL };
static const struct vsghnouiwbyk skauvfotzjza = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 128, {112, 16, 0, 0}, { 0, 3, 0x3C, 2, qlbsybjbuuwq }, { 0x80, 2, 0x0e, 1, hlwjchgwhrxt }, { 0, 2, 0x70, 4, xadprewnqthb }, { 0, 3, 0x02, 1, uaghrucblmcx }, &wotkcqwgqcsh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk ussuoboqklzs = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 64, {48, 16, 0, 0}, { 0, 1, 0x0f, 0, huxsncyaliwc }, { 0, 1, 0xc0, 6, ewocvipkuzaw }, { 0x80, 1, 0x30, 4, ygdgsrknfpiy }, { 1, 0, 0x07, 0, enbhuleqjjhe }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, falpnhpaffep, NULL };
static const struct vsghnouiwbyk etnqgcxgdpra = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 46, {46, 0, 0, 0}, { 0, 3, 0x0f, 0, qlbsybjbuuwq }, { 0, 1, 0x07, 0, wxkwcmkryxyu }, { 0, 2, 0x70, 4, vsldpvefbakr }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x38}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, otmsnntvfxwn, NULL };
static const struct vsghnouiwbyk jmscofcbmmrb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1f, 0, nemjsunvswft }, { 0, 4, 0x1f, 2, ckgvxwpdxdyf }, { 0, 4, 0x03, 0, gwmvscjwshzk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 5, 0x40}}, trsclbhfsdgr, NULL };
static const struct vsghnouiwbyk ddtmmbwuarfg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1f, 0, nemjsunvswft }, { 0, 4, 0x70, 4, acrrvmmzqyhj }, { 0, 4, 0x03, 0, gwmvscjwshzk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 3}, 5, 0x40}}, trsclbhfsdgr, NULL };
static const struct vsghnouiwbyk zfwbxcjfkwyp = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x0f, 0, huxsncyaliwc }, { 0, 5, 0xe0, 5, hsuvxgtgltjj }, { 0, 7, 0x60, 5, ygdgsrknfpiy }, { 0, 1, 0xf0, 4, mtfsewvbqxgq }, &lsawdfksfpqm, {.xdvjpfttnymn.yeltdjdwiegk={{0, 9}, 3, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0} }, rlwfjarwbyva, NULL };
static const struct vsghnouiwbyk mcsyenchtyxw = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, huxsncyaliwc }, { 0, 1, 0x07, 0, ygcjwyoxujmy }, { 0, 2, 0x07, 0, qtpbyvcfejdx }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0xc0}, .xdvjpfttnymn.umavhyptrjjy = {{0,0}, 0, 0}}, wotxnpmxljzj, NULL };
static const struct vsghnouiwbyk sprotmwvllqi = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {23, 8, 23, 8}, { 1, 0, 0x78, 3, qlbsybjbuuwq }, { 0, 0, 0x38, 3, hsuvxgtgltjj }, { 1, 0, 0x07, 0, ctwleblehvbl }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0,0}, 0, 0}}, ygcxahquzvij, NULL };
static const struct vsghnouiwbyk hqmecwqarkrn = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {25, 6, 25, 6}, { 1, 0, 0x0f, 0, auwyugwmwlso }, { 0, 0, 0xe0, 5, qqnypqpywrvq }, { 0, 1, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0}, 0, 0}}, ygcxahquzvij, NULL };
static const struct vsghnouiwbyk nmtecvulgoip = { {0, 1, 0, 0, 0, 0, 0}, 0x3C, 85, {76, 9, 0, 0}, { 0, 2, 0xFF, 0, hzaxbgzfvbgn }, { 0, 0, 0x70, 4, ltegqbgfgmvt }, { 0, 1, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 1}, 0, 0x0F}, .xdvjpfttnymn.umavhyptrjjy = {{0,0}, 0, 0}}, auqvzdazqbtj, NULL };
static const struct vsghnouiwbyk fcscuihheeml = { {0, 1, 0, 0, 0, 1, 0}, 0x36, 86, {43, 43, 0, 0}, { 0, 2, 0xf0, 4, duzqslhlvrbd }, { 0x80, 0, 0x0c, 2, qkzbyzcluece }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0, 4, 0x30, 4, gogtxxkhbwxb }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 0, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, fqgiigpemcaz, NULL };
static const struct vsghnouiwbyk tocohkcjkzna = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 10, 0x7c, 2, huxsncyaliwc }, { 0, 6, 0xe0, 5, vfbfuutoazdp}, { 0, 4, 0xe0, 5, vukdbvtfigfk}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 9, 0x20}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &kkcvhmnjrioa };
static const struct vsghnouiwbyk umuinsqkmnsg = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 2, 0x1e, 1, aekximikujqn }, { 0, 1, 0x07, 0, mpbrctckhasl }, { 0, 1, 0x38, 3, qnjhecxddjvg }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, aduwdhgzncqz, &ylbzoubndlfv };
static const struct vsghnouiwbyk zvhkxffgmics = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x1e, 1, duzqslhlvrbd }, { 0x0, 8, 0xe0, 5, bafqaozlnera }, { 0, 6, 0x70, 4, zazdvdrlgoxw }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 6, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vjmyvdqynrdc, &mqkmpsmdmiru };
static const struct vsghnouiwbyk njygywbwkqlf = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x7e, 1, ughfpjcxzynj }, { 0x0, 6, 0x0f, 0, mulochthnhgc }, { 0, 8, 0x07, 0, ctwleblehvbl }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &orenitlhzwnl };
static const struct vsghnouiwbyk mqajitxxsmfu = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 33, {1, 32, 0, 0}, { 1, 0, 0x1e, 1, pqzbdwgjzgjg }, { 1, 1, 0xe0, 5, fumlhnuvtjti }, { 1, 0, 0x60, 5, souulsuvkqvp }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, kuyrhcxxyktb, &znvsgukzefgj };
static const struct vsghnouiwbyk thqkbclxtycm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x1e, 1, nvtfnxgsqyky }, { 0x80, 6, 0x07, 0, jzebnhioprnt }, { 0, 8, 0x07, 0, xknpcbptryfb }, { 0, 8, 0xc0, 6, mislybzummhh }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &somajjvmnyqn };
static const struct vsghnouiwbyk qmbtwufeeqfl = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 108, {36, 36, 36, 0}, { 0, 2, 0xf0, 4, pqzbdwgjzgjg }, { 0, 3, 0x0c, 2, cuyzhcvurjqp }, { 0, 3, 0x03, 0, tdwegvcedrpe }, { 0, 2, 0x0c, 2, epeeaeljzebe }, &iokfcjotdmmq, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, ydnuhcvrirma, &eycioytqknsx };
static const struct vsghnouiwbyk fiqbtmhrupvz = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x1e, 1, pqzbdwgjzgjg }, { 0x0, 9, 0xe0, 5, hsuvxgtgltjj }, { 0, 7, 0x60, 5, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 7, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &ppycqtphwnuz };
static const struct vsghnouiwbyk jamxquvfkdsg = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {56, 120, 0, 0}, { 1, 10, 0x7e, 1, ughfpjcxzynj }, { 0x81, 7, 0x70, 4, tmjxndimiwqv }, { 1, 11, 0x70, 4, vsldpvefbakr }, { 1, 5, 0xF0, 4, xnxeqdrldfpq }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 7, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, vixgnerqasdw, &dpcbraygfzzq };
static const struct vsghnouiwbyk ldugexycddov = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x1e, 1, pbcogogavqpp }, { 0, 2, 0x06, 1, fonpcaohdilk }, { 0, 1, 0xc0, 6, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, gcpbulrrerdq, &xoktxtcxkstd };
static const struct vsghnouiwbyk owlrwxanofwz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x7e, 1, ughfpjcxzynj }, { 0, 1, 0xf0, 4, lnfwnedlkogu }, { 0, 1, 0x0F, 0, tdwegvcedrpe }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, gcpbulrrerdq, &apvpceeiydcx };
static const struct vsghnouiwbyk damvxrmxfnmp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 9, 0x0f, 0, qlbsybjbuuwq }, { 0, 6, 0x7f, 0, cwmdpzszkgpi }, { 0, 7, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, rlwfjarwbyva, &syjbmjkopivb };
static const struct vsghnouiwbyk uirdsamgrhxw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 0, 0x1e, 1, rlymjpnqwqxi }, { 0x80, 1, 0x03, 0, wrcxnynhcibi }, { 0, 1, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0x60, 5, cuyzhcvurjqp }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, rlwfjarwbyva, &xlctxukfagla };
static const struct vsghnouiwbyk awssoupcazci = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 2, 0x1e, 1, qlbsybjbuuwq }, { 0, 1, 0x70, 4, mjzkesqcmxsp }, { 0, 7, 0x03, 0, ufmvcxxcfxly }, { 0, 1, 0x0c, 2, batckafsxjzu }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 0}, 0, 0}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, gcpbulrrerdq, &nydfxdilyimh };
static const struct vsghnouiwbyk qorspmelxqhz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 1, 0x7e, 1, rzgdiuvzpbzk }, { 0, 0, 0x70, 4, lpolqyvgduhp }, { 0, 0, 0x07, 0, mctpbidjvrsb }, { 0, 5, 0x70, 4, nplzubhhgday }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0x09}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, rlwfjarwbyva, &kawiuujoybwz };
static const struct vsghnouiwbyk noontgieowal = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 2, 0x7e, 1, ughfpjcxzynj }, { 0, 1, 0x70, 4, lpolqyvgduhp }, { 0, 1, 0x07, 0, qnjhecxddjvg }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, trsclbhfsdgr, &ylbzoubndlfv };
static const struct vsghnouiwbyk fnaluuygdmfe = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xf8, 3, atzscyghbqee }, { 1, 2, 0x07, 0, hsuvxgtgltjj }, { 1, 3, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.jylyhhlxgchq = (bc7215DataVarPkt_t*)aouwrujpaztm}, yfkkffuyjdjc, &gtnfysdofxif };
static const struct vsghnouiwbyk mroyrcogfukl = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 68, {68, 0, 0, 0}, { 0, 1, 0x0e, 1, ekkpcyyobtwh }, { 0, 0, 0x07, 0, hsuvxgtgltjj }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, gcpbulrrerdq, &qxdzvqddehie };
static const struct vsghnouiwbyk ukcuxetjdvyq = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 7, 0xe0, 5, vfbfuutoazdp }, { 0, 5, 0xe0, 5, vukdbvtfigfk }, { 0, 12, 0x07, 0, tfnbefmjojvh }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &hotyxxcmorep };
static const struct vsghnouiwbyk wepkfdfscqze = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 1, 0xf0, 4, qlbsybjbuuwq }, { 0x0, 6, 0x07, 0, hsuvxgtgltjj }, { 0, 6, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x02}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &parpdhefvtab };
static const struct vsghnouiwbyk ngvwimfmeyod = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, qlbsybjbuuwq }, { 1, 1, 0x07, 0, einaxguqxgdv }, { 1, 0, 0x03, 0, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{2, 9}, 4, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dvlmbpsinqoo, &dlqgxetzemki };
static const struct vsghnouiwbyk wjnwczhtuuxp = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, qasyaeygoyda }, { 0, 1, 0x07, 0, ygcjwyoxujmy }, { 0, 2, 0x07, 0, qtpbyvcfejdx }, { 0, 1, 0x08, 3, wowphqlodpqt }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0xc0}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, olhrfncspuea, &gxanzhyuafjw };
static const struct vsghnouiwbyk ipkveucjvngp = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {40, 136, 0, 0}, { 1, 5, 0x1E, 1, qlbsybjbuuwq }, { 1, 6, 0x07, 0, smlahnhsfqyk }, { 1, 7, 0x0E, 1, jvocmwauessk }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x40}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dyoerhuugkim, &qwctzlqurxdy };
static const struct vsghnouiwbyk ydbbmldnfdil = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 168, {12, 44, 68, 44}, { 3, 3, 0x0f, 0, qlbsybjbuuwq }, { 3, 4, 0x07, 0, hsuvxgtgltjj }, { 3, 3, 0xe0, 5, ylmeljrhbupr }, { 0, 0, 0, 0, NULL }, &uwamrtxlewym, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x03}, .xdvjpfttnymn.umavhyptrjjy = {{3, 9}, 5, 0x03}}, lxeqknsnwmvy, &qpwvppcoajoo };
static const struct vsghnouiwbyk qzpzjfwrthog = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 170, {12, 44, 70, 44}, { 3, 3, 0x1e, 1, qlbsybjbuuwq }, { 3, 4, 0x07, 0, hsuvxgtgltjj }, { 3, 3, 0xe0, 5, ylmeljrhbupr }, { 0, 0, 0, 0, NULL }, &uwamrtxlewym, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 5, 0x03}, .xdvjpfttnymn.umavhyptrjjy = {{3, 9}, 5, 0x03}}, lxeqknsnwmvy, &kxlehxjhafxr };
static const struct vsghnouiwbyk petmgpdweweo = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 48, {40, 8, 0, 0}, { 0x80, 3, 0x0e, 1, xpatrucniagd }, { 0, 2, 0x07, 0, etirvoycmsmy }, { 0, 2, 0x60, 5, watlqftdktqz }, { 1, 0, 0x0f, 0, nbroaydguqzt }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0x10}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, yzwkptrlibny, &dzwyylvjtzmk };
static const struct vsghnouiwbyk umqwspijlhcz = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 72, {8, 64, 0, 0}, { 1, 3, 0x7e, 1, ughfpjcxzynj }, { 1, 1, 0x07, 0, hsuvxgtgltjj }, { 1, 1, 0x70, 4, cnbszmkdlatp }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, dyoerhuugkim, &iypacpobzjuo };
static const struct vsghnouiwbyk jnzhhyvqiztn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 13, 0x1e, 1, nvtfnxgsqyky }, { 0, 6, 0x0f, 0, niaotlqdftsv }, { 0, 8, 0x07, 0, xknpcbptryfb }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 5, 0x04}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &zjslofaamxyp };
static const struct vsghnouiwbyk rwdfveovpjgo = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 0, 0x1e, 1, qlbsybjbuuwq }, { 0, 1, 0xf0, 4, rnqrphdpnqzx }, { 0, 0, 0x60, 5, souulsuvkqvp }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, ybjlgbokpeap, &bkzbnevwnggk };
static const struct vsghnouiwbyk qwizybjtbyyb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1e, 1, aekximikujqn }, { 0, 2, 0x0e, 1, fumlhnuvtjti }, { 0, 1, 0x60, 5, ygdgsrknfpiy }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 2, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, rlwfjarwbyva, &zbneyfdgjmgd };
static const struct vsghnouiwbyk xodqjcutcknr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x1e, 1, aekximikujqn }, { 0, 1, 0xc0, 6, hprejobsvxdc }, { 0, 1, 0x3f, 0, awyoxyekofnl }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 8}, 2, 0x32}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, &fwvzshasvmyo };
static const struct vsghnouiwbyk swxieailoqav = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, qlbsybjbuuwq }, { 0, 1, 0x07, 0, ygcjwyoxujmy }, { 0, 2, 0x07, 0, qtpbyvcfejdx }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0xc0}, .xdvjpfttnymn.umavhyptrjjy = {{0,0}, 0, 0}}, rjvlmqcbgtfl, &gxrgmhwlrkhg };
static const struct vsghnouiwbyk wiflguavtgql = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0e, 1, ekkpcyyobtwh }, { 0, 0, 0x07, 0, fumlhnuvtjti}, { 0, 0, 0x30, 4, ygdgsrknfpiy}, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, gcpbulrrerdq, &xdyyxheudbee };
static const struct vsghnouiwbyk gnyiirrqqhyi = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 134, {35,32,35,32}, { 0, 1, 0x0f, 0, qlbsybjbuuwq }, { 0, 0, 0x07, 0, pssscpmmpywo }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, iomtqjccekux, &eftthwofcwcr };
static const struct vsghnouiwbyk bdgzjstkaojo = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 134, {35,32,35,32}, { 0, 1, 0x0f, 0, oaqarbuqcnzi }, { 0, 0, 0x07, 0, pssscpmmpywo }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, iomtqjccekux, &xiwmtfzsqzfw };
static const struct vsghnouiwbyk ncrhbvscpkbn = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xe0, 5, xwpxrjafcuyl }, { 0, 1, 0x07, 0, ygcjwyoxujmy }, { 0, 2, 0x07, 0, qtpbyvcfejdx }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 1, 0xc0}, .xdvjpfttnymn.umavhyptrjjy = {{0,0}, 0, 0}}, rjvlmqcbgtfl, &xaqmghgmbkpb };
static const struct vsghnouiwbyk xcvzjrborzuw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 1, 0x7e, 1, rzgdiuvzpbzk }, { 0, 4, 0x0e, 1, xodtxovxrqdi }, { 0, 4, 0x70, 4, watlqftdktqz }, { 0, 5, 0xff, 0, mlkdcgbktsbx }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 4, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, rlwfjarwbyva, &kawiuujoybwz };
static const struct vsghnouiwbyk ochjxctvllxd = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 40, {24, 8, 8, 0}, { 1, 0, 0xe0, 5, xgmfromrdrwl }, { 0, 1, 0x70, 4, mtqttagzkyvk }, { 0, 1, 0x03, 0, watlqftdktqz }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 1, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0,9},2,0x11}}, tckarflpcrau, &msmrusgxkqtj };
static const struct vsghnouiwbyk rpssiugcdqmb = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 104, {16, 88, 0, 0}, { 1, 1, 0x7e, 1, rzgdiuvzpbzk }, { 1, 2, 0x07, 0, vsgkdejbfslk }, { 1, 2, 0x38, 3, aglvlpkugvof }, { 0, 0, 0, 0, NULL }, &undgocczxhwe, {.xdvjpfttnymn.yeltdjdwiegk = {{1, 9}, 2, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, yfkkffuyjdjc, &hblgrlgpyoet };
static const struct vsghnouiwbyk chjvxjtvnjfs = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0xf0, 4, aekximikujqn }, { 0, 3, 0x07, 0, lcfcdrxiqyzz }, { 0, 2, 0x03, 0, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 2, 0x07}, .xdvjpfttnymn.umavhyptrjjy = {{0,0},0,0}}, gcpbulrrerdq, &njduflecdoqp };
static const struct vsghnouiwbyk mebgwbmezkqk = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfc, 2, qlbsybjbuuwq }, { 3, 5, 0x70, 4, nzrkfuvfonaq }, { 3, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL }, &nxrdhuyhzxrv, {.xdvjpfttnymn.yeltdjdwiegk = {{3, 9}, 5, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{3, 9}, 9, 0x0f}}, tqokiavwcgfc, &auaewvylxkez };
static const struct vsghnouiwbyk kvfopwxchhrg = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 312, {160, 152, 0, 0}, { 1, 6, 0xfe, 1, dirmsniyzxmk }, { 1, 5, 0x70, 4, nzrkfuvfonaq }, { 1, 8, 0xf0, 4, sodnmplfotvu }, { 0, 0, 0, 0, NULL }, &mdxfijtgnbep, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 3}, 6, 0x80}, .xdvjpfttnymn.umavhyptrjjy = {{1, 9}, 5, 0x01}}, fqdumxtpfoqx, &xzgukzrwqvln };
static const struct vsghnouiwbyk hbzwausdnyfi = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 56, {48, 8, 0, 0}, { 0, 1, 0xfe, 1, tqqemhnsqtkj }, { 0, 2, 0x0f, 0, swbgzrukfhqt }, { 0, 2, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL }, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x01}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, tcdmydkfkcqe, &kawiuujoybwz };
static const struct vsghnouiwbyk tmqowiwlbajd = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 67, {35,32,0,0}, { 0, 1, 0x0f, 0, aekximikujqn }, { 0, 0, 0x07, 0, fpcdqkhazcgk }, { 0, 0, 0x30, 4, tgvozcdkwizi }, { 0, 0, 0, 0, NULL}, &olbtwhlypieh, {.xdvjpfttnymn.yeltdjdwiegk = {{0, 9}, 0, 0x08}, .xdvjpfttnymn.umavhyptrjjy = {{0, 0}, 0, 0}}, vvivsaqmctsn, &dovydskcoyph };
static const struct vsghnouiwbyk* jywzwyhwwlhx[] = { &nqcbntpcorjm, &lavqdnlmfywx, &uqxtkwpbvaef, &lnixlwqvlojn, &rdrmpuilokvu, &bbtufostpjbn, &axvbwdtfvhkc, &qsmxzwgieita, &wufgaucrdccc, &gcxkgmwfmkkv, &tvyphljcxzkw, &kppvtjneyxhb, &cceakbeevmud, &xeqmegjnmmpr, &zkopkesbzzkw, &kaskusfbgaxm, &ljfouolbospn, &zpfemwcmdlhc, &zaqvffklbcyp, &gpqtamyqeqso, &tzipwgwupqcm, &rlfryyoglzrw, &ebfnvsnflmhb, &fbvhyfrcgtcj, &xrytsfutulct, &lojhanzqocev, &yhyihafcrqzf, &iqdlpewgtvoz, &vmqwdugblegd, &zloqfhsmqelq, &tqovgenkcvjz, &zdmoxydkfenc, &nemfndaxmwgo, &ahoqbmpvzfaz, &ahtjazfgxldu, &xocvywzuttti, &ucprgxlmtvlr, &qxlwosojboju, &amocaoutzpci, &tinqbldkzibi, &avpnqbczfhid, &xkezaitiqdge, &woieapgobeld, &btzfcptiiggh, &tppabwmpfsci, &jcfjaasgehsc, &dwfwqcqaetxc, &ucejhiuyefrv, &bxqzmmiuriyv, &eqerrehxcrry, &irfhqjyyjfex, &rpujthbsfwef, &srxdyhqmibfa, &dhofleujcyqk, &fgmnwssblgaj, &xgptoowiyydc, &ewjtujleqbzy, &hyhmmikyarju, &sjcrexjwrwdo, &zgncyrorazyy, &bhflfavdejpw, &azbagyhwbkam, &swengmrqfiyi, &nfbkkzawavpt, &bhpjvcjfkgvb, &stftccshxgnw, &cqnelpafgwig, &nzdbxyzkviod, &rhprqrmokjlb, &ezsuqdpbzkob, &htzcsdyeeraq, &uatfwllghqdo, &zjaazwkayftb, &hzvlxeswzobp, &vneficeevhug, &fvcrjmuwsxkv, &beoemlhmiccv, &kghadgokegob, &ncxukazluhfy, &htuklbdisezz, &sonenrionuiu, &ewfrcrrklmuk, &wglwzvhacgmn, &rszgjuhrfwgm, &gmcpklxaurat, &alhjruiazrwi, &dzosszksdzoo, &myjcflmkkgsc, &ukpfcrfhrgug, &kqrwyfcvgnlz, &paeqqjdsrfnt, &dbjsltpmbgoq, &xttfnmbgjwal, &wyksgpticuwi, &nrbveilpjfbw, &yeobnxyjvwij, &fndleauamszv, &zuvkfvvzyyvr, &mzcdqaqfysil, &nvryyqqoomlz, &hdxztezasnbk, &letfeiyhgyvy, &wnjkpivtckvq, &uhnrnfbmaaio, &jhuxbtudabwa, &dsognanhpusz, &kjtwgbydsbrq, &tvjbmiqkyvwz, &zkgdfyieyoxv, &kfiqxgisnmmy, &iewpqkzsaedj, &xngxarrljybh, &bpebpxzcqusj, &jpskkxgsaugj, &mrhrhhgqqtue, &sdnwwfepitur, &vtknycnjzuot, &jaipseoqfjjd, &ticlibjvrnfr, &owovpmzrtkei, &ixhwaobvqsdk, &nlbbipzajbsk, &qzfyfmozspcz, &hinfjnehedmf, &srwcsqpoanux, &nechawtmavfr, &xiumgqrccrjw, &jsmmifwtmhwr, &ljsxaptbeslq, &hsvzyjdwasju, &vkfadeonobsh, &rtprmcyraybo, &ynhxmgxuetst, &onumnaqimutd, &dacyvuezeond, &xlyyyyguhirh, &qnarboxjrxzn, &vxdzvmepjvvw, &belikbrskevt, &vdvubiodajlu, &bujdavsupzey, &bzpgxccuygdj, &xgapiyfdyqej, &ezugptpfzbsu, &amwxhlmwgweb, &usjjkfzdtivx, &tinobgdjddsw, &fychrhgzshew, &zfwbxcjfkwyp, &xprioipfdfus, &rfnrflwnuqav, &ruwlldvyquwu, &rhfhkstmsxtp, &nonrnqmxwbmk, &dxwdteyifhxf, &jnzhhyvqiztn, &kxpowzotobxt, &dhjcyvqfsjfv, &dckwpjtrcquf, &ugrwnkglmliy, &szcgozpgdhlj, &gfzhwwyanuvr, &dphdfbfzweey, &adjhkkqsdmqh, &cdkxnbhpkwur, &yqoylwgfvree, &htmqewjjuchg, &quusmcsmbrdg, &potqaxxhcsxu, &sgmoovzwkufu, &ebevanqcipbu, &ianducitsrqp, &wvybpsgtheih, &hiluulshukkt, &bbmxprqsumyr, &urfurxwqooqq, &xkdlcjkwyutn, &tunbaebrcugn, &qyiaaavqpcrj, &nrzxnreoqfes, &rmwdswfttmbu, &yqsapwqtglab, &hmmzijkzbnxa, &qcgrsxpxneke, &wpdkfzbiblvr, &ddzjxyrgrftr, &vsdfyxzyqdfv, &dsftotuwiohl, &pekcqfxtulwr, &ihyhevxycowr, &iywngrxojtws, &asmgemmtkzbl, &frgkgovuctak, &gcmchtjnfppj, &yhdblojcgnva, &qrwbqaqglhxy, &czhnihunkwan, &bxwfmlvnqwnr, &fsskyqkxdhcs, &unlmpectkiei, &tyhxfbrsvtat, &antbjenlltbx, &sbynchcbxvzz, &tpoussptlpir, &bjyacowgclrs, &xjhuruxmsxur, &ahqnxetdjfhw, &hwszgljvdrlq, &cwbxuyltciee, &yefbhjuaaukj, &gwjuvxfrhkda, &pbwzfbkdvpdh, &tnmzrgshvqop, &omblkccmiqyr, &vzyoelzqdgzg, &qehnqekdxhfv, &zpzfevkcpjud, &zkkvabkzxgem, &nfjszktunhfg, &spugopwtbinl, &iymxxfzgmije, &ynfoubjzgmxd, &rojtzzhagiut, &rubegqvxrpww, &dvrsczfkecqr, &yjxtcmaacuig, &zgbyxgpkyebe, &abcafvsejaij, &ipipwyqtpaaj, &paezwzulvdgx, &epyoqnvgghdy, &mbxiqyepxsjn, &tpomjhykpjuo, &ctgmvkldoisb, &vkkvnwdbdxmk, &wfmzshwqbivk, &ovmlwnlrsevm, &bzjfuxzokxxj, &zlgllbxgjtyv, &yxnnabussnqb, &vbzncqmbrymb, &tiaehomwqyan, &gklxmouxhpyd, &tptgodlwulpv, &yupaowqbbyxt, &qeaqrsqdkjpk, &apjkjngzznni, &jqxvxuicdqvd, &vmdcinvqgjjl, &qzqgxblouioh, &yplqlejdjgfi, &dsiqvttdffga, &cwhedsgdrjao, &skauvfotzjza, &ussuoboqklzs, &dgilrfxeerlc, &etnqgcxgdpra, &jmscofcbmmrb, &ddtmmbwuarfg, &mcsyenchtyxw, &sprotmwvllqi, &hqmecwqarkrn, &nmtecvulgoip, &fcscuihheeml, &tocohkcjkzna, &umuinsqkmnsg, &zvhkxffgmics, &njygywbwkqlf, &mqajitxxsmfu, &thqkbclxtycm, &qmbtwufeeqfl, &fiqbtmhrupvz, &jamxquvfkdsg, &ldugexycddov, &owlrwxanofwz, &damvxrmxfnmp, &uirdsamgrhxw, &awssoupcazci, &fcgssliofujs, &qorspmelxqhz, &noontgieowal, &fnaluuygdmfe, &mroyrcogfukl, &ukcuxetjdvyq, &wepkfdfscqze, &vxpodajlcgua, &ngvwimfmeyod, &wjnwczhtuuxp, &ipkveucjvngp, &bztrmruvgbmz, &ydbbmldnfdil, &wmdxzowfnxmt, &qzpzjfwrthog, &vhahdjtyhnev, &pneqdrabhsuz, &petmgpdweweo, &umqwspijlhcz, &rwdfveovpjgo, &qwizybjtbyyb, &xodqjcutcknr, &swxieailoqav, &wiflguavtgql, &gnyiirrqqhyi, &bdgzjstkaojo, &ncrhbvscpkbn, &xcvzjrborzuw, &ochjxctvllxd, &rpssiugcdqmb, &chjvxjtvnjfs, &mebgwbmezkqk, &kvfopwxchhrg, &hbzwausdnyfi, &tmqowiwlbajd, &igqwlbaumthx, &rrcjryshsgce, &unvnzhegbnrb, &grxqbegngbcc, &semrpkmgzkes, &byypyoadghjd };
static const uint16_t kbyuvmrshpgh=sizeof(jywzwyhwwlhx)/sizeof(struct vsghnouiwbyk*);
static uint8_t ipnoikyhfvsm(const lieoifkbswcz* hgdodzdmndla, uint8_t rmlgjqrjacis, bool cxgyosaemdts) { uint8_t atabkdlhwzfl;
uint8_t prkpozyhrlcy;
uint8_t czwsbpvwbczl = 0;
if (hgdodzdmndla->hgdodzdmndla != NULL) { atabkdlhwzfl = (nhbvuvmcmmez[hgdodzdmndla->mcddolhbanax&0x03][hgdodzdmndla->ovadtjwxdzya&0x3f]&hgdodzdmndla->maltsbbficvg)>>(hgdodzdmndla->afuqqmowbboa&0x07);
prkpozyhrlcy = hgdodzdmndla->hgdodzdmndla[rmlgjqrjacis]&(hgdodzdmndla->maltsbbficvg>>(hgdodzdmndla->afuqqmowbboa&0x07));
if (hgdodzdmndla->mcddolhbanax&0x20) { const struct sxpegamfsrfd* ttbrlfwfvpmw = (const struct sxpegamfsrfd*)(hgdodzdmndla->hgdodzdmndla);
prkpozyhrlcy = ((const uint8_t*)ttbrlfwfvpmw->hffaidvvtesl)[rmlgjqrjacis];
} if (!(hgdodzdmndla->mcddolhbanax & 0x40)) { if (hgdodzdmndla->ovadtjwxdzya & 0x80) { czwsbpvwbczl = ((prkpozyhrlcy&0xf0)-(atabkdlhwzfl&0xf0)) | ((prkpozyhrlcy-atabkdlhwzfl)&0x0f);
} else if (hgdodzdmndla->ovadtjwxdzya & 0x40) { czwsbpvwbczl = ((prkpozyhrlcy>>4)+(prkpozyhrlcy&0x0f)) - ((atabkdlhwzfl>>4)+(atabkdlhwzfl&0x0f));
} else { czwsbpvwbczl = prkpozyhrlcy - atabkdlhwzfl;
} } if (cxgyosaemdts) { nhbvuvmcmmez[hgdodzdmndla->mcddolhbanax&0x03][hgdodzdmndla->ovadtjwxdzya&0x3f] = (nhbvuvmcmmez[hgdodzdmndla->mcddolhbanax&0x03][hgdodzdmndla->ovadtjwxdzya&0x3f]&(~hgdodzdmndla->maltsbbficvg)) | ((prkpozyhrlcy<<(hgdodzdmndla->afuqqmowbboa&0x07))&hgdodzdmndla->maltsbbficvg);
} } return czwsbpvwbczl;
} static uint8_t edebutywnedh(const lieoifkbswcz* hgdodzdmndla, uint8_t rmlgjqrjacis, bool cxgyosaemdts) { uint8_t czwsbpvwbczl = 0;
uint8_t zbsbxrmgwhhr;
const lieoifkbswcz* fcnqdoabctnl;
if (hgdodzdmndla->mcddolhbanax&0x10) { fcnqdoabctnl = (const lieoifkbswcz*)hgdodzdmndla->hgdodzdmndla;
for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<hgdodzdmndla->afuqqmowbboa; zbsbxrmgwhhr++)
{ czwsbpvwbczl |= ipnoikyhfvsm(&fcnqdoabctnl[zbsbxrmgwhhr], rmlgjqrjacis, cxgyosaemdts);
} } else { czwsbpvwbczl = ipnoikyhfvsm(hgdodzdmndla, rmlgjqrjacis, cxgyosaemdts);
} return czwsbpvwbczl;
} static bool qzuszmtpefbs(const struct vsghnouiwbyk* cssjkjaqtock, bool ahyzslokqilb) { uint8_t zbsbxrmgwhhr = 0;
algorithm_t lfnyzttyzqex;
jixidamdohep = NULL;
while (cssjkjaqtock->watvzlijecjx[zbsbxrmgwhhr].lkwfsmdlhdgq != NULL) { lfnyzttyzqex = cssjkjaqtock->watvzlijecjx[zbsbxrmgwhhr].lkwfsmdlhdgq;
if (!lfnyzttyzqex(cssjkjaqtock, cssjkjaqtock->watvzlijecjx[zbsbxrmgwhhr].coblviwgccvs, ahyzslokqilb)) { return false;
} zbsbxrmgwhhr++;
} return true;
} static bool ocfvqbiqxxim(const struct utzzewolswpc* xdvjpfttnymn, bool ahyzslokqilb) { uint8_t bjhecxhqgqas;
bjhecxhqgqas = nhbvuvmcmmez[xdvjpfttnymn->mekzztbhyjqh.isosilhghoqn][xdvjpfttnymn->ovadtjwxdzya];
if (ahyzslokqilb) { nhbvuvmcmmez[xdvjpfttnymn->mekzztbhyjqh.isosilhghoqn][xdvjpfttnymn->ovadtjwxdzya] = mjxneimtqttw[xdvjpfttnymn->mekzztbhyjqh.enrplqfjlsgv](bjhecxhqgqas, xdvjpfttnymn->bits);
return true;
} else { return nhbvuvmcmmez[xdvjpfttnymn->mekzztbhyjqh.isosilhghoqn][xdvjpfttnymn->ovadtjwxdzya] == mjxneimtqttw[xdvjpfttnymn->mekzztbhyjqh.enrplqfjlsgv](bjhecxhqgqas, xdvjpfttnymn->bits);
} } static void rqmmmuvrfikr(bc7215DataVarPkt_t* ulvlopcjlbnz, int8_t hrdpespiedic, uint8_t roadpqxtnnar) { uint8_t zbsbxrmgwhhr;
int8_t xogdafopzzfe;
bool shiftOutBit=0;
for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<roadpqxtnnar; zbsbxrmgwhhr++)
{ for (xogdafopzzfe=(ulvlopcjlbnz->bitLen+7)/8-1; xogdafopzzfe>=hrdpespiedic; xogdafopzzfe--)
{ if (ulvlopcjlbnz->data[xogdafopzzfe] & 0x80) { ulvlopcjlbnz->data[xogdafopzzfe] <<= 1;
if (shiftOutBit == 1) { ulvlopcjlbnz->data[xogdafopzzfe] |= 0x01;
} shiftOutBit = 1;
} else { ulvlopcjlbnz->data[xogdafopzzfe] <<= 1;
if (shiftOutBit == 1) { ulvlopcjlbnz->data[xogdafopzzfe] |= 0x01;
} shiftOutBit = 0;
} } } } static void grpfxucgnruq(bc7215DataVarPkt_t* ulvlopcjlbnz, int8_t hrdpespiedic, uint8_t roadpqxtnnar) { uint8_t zbsbxrmgwhhr;
int8_t xogdafopzzfe;
bool shiftOutBit=0;
for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<roadpqxtnnar; zbsbxrmgwhhr++)
{ for (xogdafopzzfe=(ulvlopcjlbnz->bitLen+7)/8-1; xogdafopzzfe>=hrdpespiedic; xogdafopzzfe--)
{ if (ulvlopcjlbnz->data[xogdafopzzfe] & 0x01) { ulvlopcjlbnz->data[xogdafopzzfe] >>= 1;
if (shiftOutBit == 1) { ulvlopcjlbnz->data[xogdafopzzfe] |= 0x80;
} shiftOutBit = 1;
} else { ulvlopcjlbnz->data[xogdafopzzfe] >>= 1;
if (shiftOutBit == 1) { ulvlopcjlbnz->data[xogdafopzzfe] |= 0x80;
} shiftOutBit = 0;
} } } } static void mfvmvvsrgpmq(uint8_t mekzztbhyjqh[][BC7215_MAX_RX_DATA_SIZE], bc7215DataVarPkt_t* ulvlopcjlbnz, const struct vsghnouiwbyk* cssjkjaqtock) { uint16_t noeqfrjfnbkw = 0;
uint8_t conewbandlaz = 0;
uint8_t zbsbxrmgwhhr;
uint8_t binbdllxxutl = 0;
uint8_t iigdpskkkics;
uint8_t cwtlqowljkvm;
uint16_t naulgzitqyhv;
naulgzitqyhv = cssjkjaqtock->kbuoarkttzag[0]+cssjkjaqtock->kbuoarkttzag[1]+cssjkjaqtock->kbuoarkttzag[2]+cssjkjaqtock->kbuoarkttzag[3];
while (noeqfrjfnbkw < naulgzitqyhv) { iigdpskkkics = binbdllxxutl+(cssjkjaqtock->kbuoarkttzag[conewbandlaz]+7)/8;
for (zbsbxrmgwhhr=binbdllxxutl; zbsbxrmgwhhr<iigdpskkkics; zbsbxrmgwhhr++)
{ mekzztbhyjqh[conewbandlaz][zbsbxrmgwhhr-binbdllxxutl] = ulvlopcjlbnz->data[zbsbxrmgwhhr];
} cwtlqowljkvm = cssjkjaqtock->kbuoarkttzag[conewbandlaz]%8;
if (cwtlqowljkvm != 0) { if ((cssjkjaqtock->signature&0x30) == 0x30) { mekzztbhyjqh[conewbandlaz][iigdpskkkics-binbdllxxutl-1] &= gtlmwdqemewe[cwtlqowljkvm];
grpfxucgnruq(ulvlopcjlbnz, iigdpskkkics-1, cwtlqowljkvm);
} else { mekzztbhyjqh[conewbandlaz][iigdpskkkics-binbdllxxutl-1] &= zcrduqdktess[cwtlqowljkvm];
rqmmmuvrfikr(ulvlopcjlbnz, iigdpskkkics-1, cwtlqowljkvm);
} binbdllxxutl = iigdpskkkics-1;
} else { binbdllxxutl = iigdpskkkics;
} noeqfrjfnbkw += cssjkjaqtock->kbuoarkttzag[conewbandlaz];
conewbandlaz++;
} } static uint8_t nnkrhrkeffev(uint8_t byte) { return (tqvtyeimyhpa[byte & 0x0F] << 4) | tqvtyeimyhpa[byte >> 4];
} static uint8_t sjzgkdjqvgzq(uint8_t byte) { return (lxlfwpcgkpnw[byte >> 4]<<4) | lxlfwpcgkpnw[byte & 0x0f];
} static void uubekixzgshu(const struct vsghnouiwbyk* cssjkjaqtock) { uint8_t zbsbxrmgwhhr, xogdafopzzfe;
for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<4; zbsbxrmgwhhr++)
{ for (xogdafopzzfe=0; xogdafopzzfe<(cssjkjaqtock->kbuoarkttzag[zbsbxrmgwhhr]+7)/8; xogdafopzzfe++)
{ nhbvuvmcmmez[zbsbxrmgwhhr][xogdafopzzfe] = nnkrhrkeffev(nhbvuvmcmmez[zbsbxrmgwhhr][xogdafopzzfe]);
} } } static void musinwgvcyci(const struct vsghnouiwbyk* cssjkjaqtock) { uint8_t zbsbxrmgwhhr, xogdafopzzfe;
for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<4; zbsbxrmgwhhr++)
{ for (xogdafopzzfe=0; xogdafopzzfe<(cssjkjaqtock->kbuoarkttzag[zbsbxrmgwhhr]+7)/8; xogdafopzzfe++)
{ nhbvuvmcmmez[zbsbxrmgwhhr][xogdafopzzfe] = sjzgkdjqvgzq(nhbvuvmcmmez[zbsbxrmgwhhr][xogdafopzzfe]);
} } } static bool jjnbcsyhvcga(const struct vsghnouiwbyk* cssjkjaqtock) { uint8_t xjgqucrcjtuj;
if (fahrenheitInit) { if (ylalbobacimq->nhaqybpfptll != NULL) { xjgqucrcjtuj = ylalbobacimq->nhaqybpfptll->iqhduifjeusb[nwafzsyodvlc-60];
} else { xjgqucrcjtuj = ghgjjuztaesj.iqhduifjeusb[nwafzsyodvlc-60];
} } else { xjgqucrcjtuj = cdceqlsppczl-16;
} if (ipnoikyhfvsm(&cssjkjaqtock->urotzxmebdry, xjgqucrcjtuj, dieecgizrxee) != 0) { return false;
} if (ipnoikyhfvsm(&cssjkjaqtock->rozfsolwsfzh, MODE_COOL, dieecgizrxee) != 0) { return false;
} return qzuszmtpefbs(cssjkjaqtock, dieecgizrxee);
} static int8_t gvmzfeyguymh(const lieoifkbswcz* hgdodzdmndla, uint8_t bgxrgfmymfwn) { lieoifkbswcz smnosuqabxcv = *hgdodzdmndla;
int8_t zbsbxrmgwhhr;
smnosuqabxcv.mcddolhbanax &= 0x3F;
zbsbxrmgwhhr = bgxrgfmymfwn/2;
while (zbsbxrmgwhhr >= 0) { if (ipnoikyhfvsm(&smnosuqabxcv, zbsbxrmgwhhr, dieecgizrxee) == 0) { return zbsbxrmgwhhr;
} zbsbxrmgwhhr--;
} for (zbsbxrmgwhhr=bgxrgfmymfwn/2+1; zbsbxrmgwhhr<bgxrgfmymfwn; zbsbxrmgwhhr++)
{ if (ipnoikyhfvsm(&smnosuqabxcv, zbsbxrmgwhhr, dieecgizrxee) == 0) { return zbsbxrmgwhhr;
} } return -1;
} static int8_t wgocioibmpsi(const struct wscodbmjbktx* mgqnuqcefqhy) { int8_t zbsbxrmgwhhr;
int8_t qxmdmyxasydo, xtxmdvizxndc;
int8_t ncpzpizkzeve = -1;
lieoifkbswcz smnosuqabxcv = ylalbobacimq->urotzxmebdry;
smnosuqabxcv.mcddolhbanax &= 0x3f;
for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<15; zbsbxrmgwhhr++)
{ qxmdmyxasydo = 14-zbsbxrmgwhhr;
xtxmdvizxndc = 15+zbsbxrmgwhhr;
if (ipnoikyhfvsm(&smnosuqabxcv, mgqnuqcefqhy->iqhduifjeusb[qxmdmyxasydo], dieecgizrxee) == 0) { ncpzpizkzeve = qxmdmyxasydo;
if (mgqnuqcefqhy->vzkqjiprdpjc.hgdodzdmndla != NULL ) { if (edebutywnedh(&mgqnuqcefqhy->vzkqjiprdpjc, qxmdmyxasydo, dieecgizrxee) == 0) { return ncpzpizkzeve;
} } } if ((xtxmdvizxndc<=28) && (ipnoikyhfvsm(&smnosuqabxcv, mgqnuqcefqhy->iqhduifjeusb[xtxmdvizxndc], dieecgizrxee) == 0)) { ncpzpizkzeve = xtxmdvizxndc;
if (mgqnuqcefqhy->vzkqjiprdpjc.hgdodzdmndla != NULL ) { if (edebutywnedh(&mgqnuqcefqhy->vzkqjiprdpjc, xtxmdvizxndc, dieecgizrxee) == 0) { return ncpzpizkzeve;
} } } } return ncpzpizkzeve;
} static int8_t iznnydsjihel(const struct vsghnouiwbyk* cssjkjaqtock) { int8_t dskbycvacpfu;
dskbycvacpfu = 1;
if (!cssjkjaqtock->spec.ymmnbayvgjbe) { if ((cssjkjaqtock->wlujocdbskis.hgdodzdmndla != NULL) && (cssjkjaqtock->wlujocdbskis.hgdodzdmndla[0] != cssjkjaqtock->wlujocdbskis.hgdodzdmndla[4]) && !((cssjkjaqtock->urotzxmebdry.mcddolhbanax&0x80) || (cssjkjaqtock->rozfsolwsfzh.mcddolhbanax&0x80) || (cssjkjaqtock->ofajzwessiol.mcddolhbanax&0x80))) { if (ipnoikyhfvsm(&cssjkjaqtock->wlujocdbskis, 4, dieecgizrxee) == 0) { if (cssjkjaqtock->wlujocdbskis.hgdodzdmndla[4] == cssjkjaqtock->wlujocdbskis.hgdodzdmndla[5]) { dskbycvacpfu = 2;
} else { dskbycvacpfu = 0;
return dskbycvacpfu;
} } } if ( !( (ylalbobacimq->lzjiegmlwhzf.xdvjpfttnymn.yeltdjdwiegk.mekzztbhyjqh.enrplqfjlsgv == 0) && (ylalbobacimq->lzjiegmlwhzf.xdvjpfttnymn.yeltdjdwiegk.bits == 0) && (ylalbobacimq->lzjiegmlwhzf.xdvjpfttnymn.umavhyptrjjy.mekzztbhyjqh.enrplqfjlsgv == 0) && (ylalbobacimq->lzjiegmlwhzf.xdvjpfttnymn.umavhyptrjjy.bits == 0) ) ) { if ( ocfvqbiqxxim(&ylalbobacimq->lzjiegmlwhzf.xdvjpfttnymn.yeltdjdwiegk, dieecgizrxee) && ocfvqbiqxxim(&ylalbobacimq->lzjiegmlwhzf.xdvjpfttnymn.umavhyptrjjy, dieecgizrxee) ) { dskbycvacpfu = 0;
} else if (dskbycvacpfu == 2) { dskbycvacpfu = 1;
} if (cssjkjaqtock->spec.cmdkwamqxjvi) { if (dskbycvacpfu == 1) { dskbycvacpfu = -1;
} else { dskbycvacpfu = 2;
} } } } else { dskbycvacpfu = -1;
} return dskbycvacpfu;
} static uint8_t gqmcotevjdlf(uint8_t ulvlopcjlbnz, uint8_t bits, uint8_t* jtpeziwhttww) { uint8_t byte;
if ((bits != 8) && (bits != 0)) { byte = ulvlopcjlbnz&gtlmwdqemewe[bits];
ulvlopcjlbnz >>= bits;
ulvlopcjlbnz |= (*jtpeziwhttww<<(8-bits));
*jtpeziwhttww = byte;
} return ulvlopcjlbnz;
} static uint8_t nihsdvwrwdok(uint8_t ulvlopcjlbnz, uint8_t bits, uint8_t* jtpeziwhttww) { uint8_t byte;
if ((bits != 8) && (bits != 0)) { byte = ulvlopcjlbnz&zcrduqdktess[bits];
ulvlopcjlbnz <<= bits;
ulvlopcjlbnz |= (*jtpeziwhttww>>(8-bits));
*jtpeziwhttww = byte;
} return ulvlopcjlbnz;
} static void gefhjoxgjdgt(const struct vsghnouiwbyk* cssjkjaqtock) { uint8_t mcddolhbanax;
uint16_t xogdafopzzfe;
uint8_t wvlrpkxtsolz = 0;
uint16_t igftupmalrfe = 0;
uint8_t flcjntcrbgoi = 0;
uint8_t qyijmidcihgt = 0;
uint8_t roadpqxtnnar = 0;
uint8_t ujhiewtyxcqw;
nheotrjqxqej.bitLen = cssjkjaqtock->bitLen;
for (mcddolhbanax = 0; mcddolhbanax < 4; mcddolhbanax++) {
if (cssjkjaqtock->kbuoarkttzag[mcddolhbanax] != 0) { for (xogdafopzzfe = 0; xogdafopzzfe < (cssjkjaqtock->kbuoarkttzag[mcddolhbanax]-roadpqxtnnar+7)/8; xogdafopzzfe++) {
flcjntcrbgoi = gqikxxqqjecf[mcddolhbanax][xogdafopzzfe+1];
if ((cssjkjaqtock->signature&0x30) == 0x30) { nheotrjqxqej.data[wvlrpkxtsolz] = gqmcotevjdlf(gqikxxqqjecf[mcddolhbanax][xogdafopzzfe], roadpqxtnnar, &flcjntcrbgoi);
} else { nheotrjqxqej.data[wvlrpkxtsolz] = nihsdvwrwdok(gqikxxqqjecf[mcddolhbanax][xogdafopzzfe], roadpqxtnnar, &flcjntcrbgoi);
} wvlrpkxtsolz++;
} igftupmalrfe += cssjkjaqtock->kbuoarkttzag[mcddolhbanax];
qyijmidcihgt = igftupmalrfe%8;
roadpqxtnnar = (8-qyijmidcihgt)&0x07;
if ((roadpqxtnnar != 0) && (mcddolhbanax != 3) && (cssjkjaqtock->kbuoarkttzag[mcddolhbanax+1] != 0)){ if ((cssjkjaqtock->signature&0x30) == 0x30) { nheotrjqxqej.data[wvlrpkxtsolz-1] = (nheotrjqxqej.data[wvlrpkxtsolz-1]&gtlmwdqemewe[qyijmidcihgt]) | (gqikxxqqjecf[mcddolhbanax+1][0] << qyijmidcihgt);
} else { nheotrjqxqej.data[wvlrpkxtsolz-1] = (nheotrjqxqej.data[wvlrpkxtsolz-1]&zcrduqdktess[qyijmidcihgt]) | (gqikxxqqjecf[mcddolhbanax+1][0] >> qyijmidcihgt);
} } } } if (cssjkjaqtock->spec.haibeofkrlkw && cssjkjaqtock->spec.zqbpbblioehh) { memcpy(iukuxevqncnf.data, nheotrjqxqej.data, (nheotrjqxqej.bitLen+7)/8);
memcpy(nheotrjqxqej.data, exhfmkybxmek.data, (nheotrjqxqej.bitLen+7)/8);
igftupmalrfe = 0;
for (xogdafopzzfe=0; xogdafopzzfe<nheotrjqxqej.bitLen/2; xogdafopzzfe++)
{ wvlrpkxtsolz = xogdafopzzfe/4;
ujhiewtyxcqw = nheotrjqxqej.data[wvlrpkxtsolz] & qblmsoegqftp[xogdafopzzfe%4];
if ((ujhiewtyxcqw & 0xaa) == 0) { if (iukuxevqncnf.data[igftupmalrfe/8] & qrrxjwzecfmd[igftupmalrfe%8]) { nheotrjqxqej.data[wvlrpkxtsolz] = (nheotrjqxqej.data[wvlrpkxtsolz]&(~qblmsoegqftp[xogdafopzzfe%4])) | (0x55 & qblmsoegqftp[xogdafopzzfe%4]);
} else { nheotrjqxqej.data[wvlrpkxtsolz] = nheotrjqxqej.data[wvlrpkxtsolz] & (~qblmsoegqftp[xogdafopzzfe%4]);
} igftupmalrfe++;
} } } } static void spitddtdgatl(const struct vsghnouiwbyk* cssjkjaqtock, uint8_t ysvohcihtbrc, const bc7215DataVarPkt_t* ulvlopcjlbnz) { uint8_t drkbvldzxnru;
uint8_t xogdafopzzfe, rphxmsxdvoml;
uint16_t igftupmalrfe;
uint8_t ujhiewtyxcqw;
igftupmalrfe = 0;
iukuxevqncnf.bitLen = ulvlopcjlbnz->bitLen;
drkbvldzxnru = (ulvlopcjlbnz->bitLen+7)/8;
if (cssjkjaqtock->bitLen != ulvlopcjlbnz->bitLen) { pktLenChanged = true;
} else { pktLenChanged = false;
} for (xogdafopzzfe=0; xogdafopzzfe<drkbvldzxnru; xogdafopzzfe++) {
if (cssjkjaqtock->spec.haibeofkrlkw && cssjkjaqtock->spec.zqbpbblioehh) { for (rphxmsxdvoml= 0; rphxmsxdvoml < 4; rphxmsxdvoml++) {
ujhiewtyxcqw = ulvlopcjlbnz->data[xogdafopzzfe] & qblmsoegqftp[rphxmsxdvoml];
if ((ujhiewtyxcqw & 0xaa) == 0) { if ((ujhiewtyxcqw & 0x55) == 0) { iukuxevqncnf.data[igftupmalrfe/8] &= ~qrrxjwzecfmd[igftupmalrfe%8];
} else { iukuxevqncnf.data[igftupmalrfe/8] |= qrrxjwzecfmd[igftupmalrfe%8];
} igftupmalrfe++;
} } } else if (ysvohcihtbrc&0x40) { iukuxevqncnf.data[xogdafopzzfe] = ~ulvlopcjlbnz->data[xogdafopzzfe];
} else { iukuxevqncnf.data[xogdafopzzfe] = ulvlopcjlbnz->data[xogdafopzzfe];
} } ckbvbvcobbdk(cssjkjaqtock, (bc7215DataVarPkt_t*)&iukuxevqncnf);
} static void ckbvbvcobbdk(const struct vsghnouiwbyk* cssjkjaqtock, bc7215DataVarPkt_t* ulvlopcjlbnz) { mfvmvvsrgpmq(nhbvuvmcmmez, ulvlopcjlbnz, cssjkjaqtock);
if (cssjkjaqtock->spec.xhxfnnwqvdiy) { uubekixzgshu(cssjkjaqtock);
} if (cssjkjaqtock->spec.haibeofkrlkw && !cssjkjaqtock->spec.zqbpbblioehh) { musinwgvcyci(cssjkjaqtock);
} } static void qswuykmdmlug(const struct vsghnouiwbyk* cssjkjaqtock) { uint8_t zbsbxrmgwhhr, xogdafopzzfe;
uint8_t hwubnddjolvl;
uint8_t drkbvldzxnru;
for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<4; zbsbxrmgwhhr++)
{ drkbvldzxnru = (cssjkjaqtock->kbuoarkttzag[zbsbxrmgwhhr]+7)/8;
for (xogdafopzzfe=0; xogdafopzzfe<drkbvldzxnru; xogdafopzzfe++)
{ hwubnddjolvl = nhbvuvmcmmez[zbsbxrmgwhhr][xogdafopzzfe];
if (cssjkjaqtock->spec.haibeofkrlkw && !cssjkjaqtock->spec.zqbpbblioehh) { hwubnddjolvl = sjzgkdjqvgzq(hwubnddjolvl);
} if (cssjkjaqtock->spec.xhxfnnwqvdiy) { hwubnddjolvl = nnkrhrkeffev(hwubnddjolvl);
} if (ymndlmvtogxm & 0x40) { hwubnddjolvl = ~hwubnddjolvl;
} gqikxxqqjecf[zbsbxrmgwhhr][xogdafopzzfe] = hwubnddjolvl;
} } } static void ujgpijslocme(const struct pktfcxxfncig* coblviwgccvs) { uint8_t noirgnwyfkdq;
uint8_t czwsbpvwbczl;
uint8_t dskbycvacpfu;
uint8_t fqalxysuvvwm;
fqalxysuvvwm = coblviwgccvs->fqalxysuvvwm&0x03;
noirgnwyfkdq = nhbvuvmcmmez[fqalxysuvvwm][coblviwgccvs->tkplxpajzfyb];
czwsbpvwbczl = (daileifiahoj[coblviwgccvs->bkpjwqksrjra]&coblviwgccvs->tqcxlbpdyumb)<<coblviwgccvs->rrcbdmmkoaaz;
dskbycvacpfu = mjxneimtqttw[coblviwgccvs->enrplqfjlsgv.enrplqfjlsgv](noirgnwyfkdq, czwsbpvwbczl);
noirgnwyfkdq = (noirgnwyfkdq&(~coblviwgccvs->wiizqupdjedy)) | (dskbycvacpfu&coblviwgccvs->wiizqupdjedy);
nhbvuvmcmmez[fqalxysuvvwm][coblviwgccvs->tkplxpajzfyb] = noirgnwyfkdq;
} static void wkktcftsgcrh(void) { lbytyamdflsf = dayyhlonocwg;
eokpcvziyoim = exhfmkybxmek;
} static void rfbtqpwrfskw(void) { dayyhlonocwg = lbytyamdflsf;
exhfmkybxmek = eokpcvziyoim;
} static bool gwtlojdyjddv(uint16_t ouejkknsqeke) { ylalbobacimq = jywzwyhwwlhx[ouejkknsqeke];
altProtocolUsing = false;
if (((ymndlmvtogxm&0xbf) == ylalbobacimq->signature) && (exhfmkybxmek.bitLen == ylalbobacimq->bitLen)) { spitddtdgatl(ylalbobacimq, ymndlmvtogxm, (const bc7215DataVarPkt_t*)&exhfmkybxmek);
if (jjnbcsyhvcga(ylalbobacimq)) { if (ylalbobacimq->rozfsolwsfzh.mcddolhbanax&0x20) { ((const struct sxpegamfsrfd*)ylalbobacimq->rozfsolwsfzh.hgdodzdmndla)->cssjkjaqtock.lzjiegmlwhzf.dmfwafbbczce(NULL, NULL);
} return true;
} } return false;
} static bool kkmytcenwsqk(bc7215FormatPkt_t* format, uint16_t nuxphdlgtwhq, uint8_t gukarciyihed, uint8_t qiplgeopecdc) { uint8_t zbsbxrmgwhhr, xogdafopzzfe, oldSpecial, newSpecial, oldTypeCnt;
uint16_t lfhygthupjbo;
uint8_t*  jzsnmikusgja;
uint8_t*  njaiiihfjodv;
jzsnmikusgja = (uint8_t*)format;
oldSpecial = (*jzsnmikusgja&0x07)^0x05;
newSpecial =  oldSpecial*(gukarciyihed+1)+gukarciyihed;
if (newSpecial >8) { return false;
} *jzsnmikusgja = (*jzsnmikusgja&0xf8)+(newSpecial^5);
jzsnmikusgja += 9;
oldTypeCnt = *jzsnmikusgja;
*jzsnmikusgja++ = (((oldTypeCnt^0x1d)&0x7f)+1)^29;
*jzsnmikusgja = (*jzsnmikusgja&0x80)+(newSpecial^29);
jzsnmikusgja++;
if ((oldTypeCnt&0x7f) == 29) { *jzsnmikusgja++ = ((*((uint8_t*)format+1)^29)/2)^29;
*jzsnmikusgja = 226;
} else { jzsnmikusgja = jzsnmikusgja+2*(oldTypeCnt^29);
*(jzsnmikusgja++) = ((*((uint8_t*)format+1)^29)+1)/2;
*jzsnmikusgja = 0xff;
} njaiiihfjodv = (uint8_t*)format+17;
jzsnmikusgja = njaiiihfjodv+oldSpecial*2;
for (xogdafopzzfe=0; xogdafopzzfe<gukarciyihed; xogdafopzzfe++)
{ lfhygthupjbo = ((nuxphdlgtwhq*(xogdafopzzfe+1)) |((oldTypeCnt^0x1d)<<12))|0x8000;
*jzsnmikusgja++ = lfhygthupjbo&0xff;
*jzsnmikusgja++ = lfhygthupjbo>>8;
for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<oldSpecial; zbsbxrmgwhhr++)
{ newSpecial = *(njaiiihfjodv+zbsbxrmgwhhr*2);
oldTypeCnt = *(njaiiihfjodv+zbsbxrmgwhhr*2+1);
lfhygthupjbo = (nuxphdlgtwhq*(xogdafopzzfe+1)+ (newSpecial | ((oldTypeCnt<<8)&0x0fff))) | ((oldTypeCnt<<8)&0xf000);
*jzsnmikusgja++ = lfhygthupjbo&0xff;
*jzsnmikusgja++ = lfhygthupjbo>>8;
} } if (newSpecial < 8) { *((uint8_t*)format+31) = qiplgeopecdc;
} return true;
} static void obnxqalbogab(const struct vsghnouiwbyk* cssjkjaqtock) { const struct fehyfyrgmlkh*  ckfkxrimjrfl;
altProtocolUsing = true;
wkktcftsgcrh();
ckfkxrimjrfl = (const struct fehyfyrgmlkh*)cssjkjaqtock->urjrhromzium->set.rvrkwqgflpkv;
kkmytcenwsqk(&dayyhlonocwg, exhfmkybxmek.bitLen, ckfkxrimjrfl->gukarciyihed, ckfkxrimjrfl->qiplgeopecdc);
qzuszmtpefbs(ckfkxrimjrfl->cssjkjaqtock, xclzxnzrkvdh);
qswuykmdmlug(ckfkxrimjrfl->cssjkjaqtock);
gefhjoxgjdgt(ckfkxrimjrfl->cssjkjaqtock);
ylalbobacimq = ckfkxrimjrfl->cssjkjaqtock;
ymndlmvtogxm = dayyhlonocwg.signature.bits.sig;
bc7215_ac_replace_base(ymndlmvtogxm, (const bc7215DataVarPkt_t*)&nheotrjqxqej);
} static bool fcfezowamxqr(uint16_t cxwllctrtvxa, uint8_t bkpjwqksrjra, uint8_t lymhvfmngirb) { if (lymhvfmngirb == 0) { lymhvfmngirb = 60;
} if (lymhvfmngirb < 37) { lymhvfmngirb = 37;
} if (lymhvfmngirb > 72) { lymhvfmngirb = 72;
} lymhvfmngirb = (lymhvfmngirb*7)&0xff;
if (bkpjwqksrjra > 1) { if (!kkmytcenwsqk(&dayyhlonocwg, cxwllctrtvxa, bkpjwqksrjra-1, lymhvfmngirb)) { return false;
} } return true;
} static bool rthpwldrqgbh(uint8_t juostbfhgyaw, const bc7215CombinedMsg_t hundllzjmjvv[]) { uint8_t zbsbxrmgwhhr, drkbvldzxnru;
uint16_t etdfmkkffzhl;
struct vsghnouiwbyk finjgceabaok= {0};
etdfmkkffzhl = 0;
if ((juostbfhgyaw > 0) && (juostbfhgyaw <= 4)) { for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<4; zbsbxrmgwhhr++)
{ if (zbsbxrmgwhhr < juostbfhgyaw) { finjgceabaok.kbuoarkttzag[zbsbxrmgwhhr] = hundllzjmjvv[zbsbxrmgwhhr].body.msg.datPkt->bitLen;
etdfmkkffzhl += finjgceabaok.kbuoarkttzag[zbsbxrmgwhhr];
drkbvldzxnru = (finjgceabaok.kbuoarkttzag[zbsbxrmgwhhr]+7)/8;
memcpy(gqikxxqqjecf[zbsbxrmgwhhr], hundllzjmjvv[zbsbxrmgwhhr].body.msg.datPkt->data, drkbvldzxnru);
} else { finjgceabaok.kbuoarkttzag[zbsbxrmgwhhr] = 0;
} } finjgceabaok.bitLen = etdfmkkffzhl;
gefhjoxgjdgt(&finjgceabaok);
return true;
} return false;
} static void gzeafamodmeb(const struct vsghnouiwbyk* cssjkjaqtock) { const srbjiaxreyht* inmcnwbfvdrq;
if (cssjkjaqtock->wlujocdbskis.mcddolhbanax&0x80) { inmcnwbfvdrq = ((const struct fehyfyrgmlkh*)cssjkjaqtock->urjrhromzium->set.rvrkwqgflpkv)->hffaidvvtesl;
} else { inmcnwbfvdrq = cssjkjaqtock->urjrhromzium->set.rvrkwqgflpkv;
} while ((inmcnwbfvdrq != NULL) && (inmcnwbfvdrq->swagwauldrhl != NULL)) { if ((awafvcglyvyh[inmcnwbfvdrq->wehefbyxzswp] >= 0) && (awafvcglyvyh[inmcnwbfvdrq->wehefbyxzswp] < 0x0f)) { nhbvuvmcmmez[inmcnwbfvdrq->mcddolhbanax][inmcnwbfvdrq->ovadtjwxdzya&0x3f] = (nhbvuvmcmmez[inmcnwbfvdrq->mcddolhbanax][inmcnwbfvdrq->ovadtjwxdzya&0x3f]&(~inmcnwbfvdrq->maltsbbficvg)) | (inmcnwbfvdrq->swagwauldrhl[awafvcglyvyh[inmcnwbfvdrq->wehefbyxzswp]]&inmcnwbfvdrq->maltsbbficvg);
} inmcnwbfvdrq++;
} } static const bc7215DataVarPkt_t* rjnjgrjfaldn(uint8_t newlbelwshvz) { spitddtdgatl(ylalbobacimq, ymndlmvtogxm, (const bc7215DataVarPkt_t*)&exhfmkybxmek);
if ((newlbelwshvz == 4) || ylalbobacimq->spec.cmdkwamqxjvi) { ocfvqbiqxxim(&ylalbobacimq->lzjiegmlwhzf.xdvjpfttnymn.yeltdjdwiegk, xclzxnzrkvdh);
ocfvqbiqxxim(&ylalbobacimq->lzjiegmlwhzf.xdvjpfttnymn.umavhyptrjjy, xclzxnzrkvdh);
} daileifiahoj[0] = 0;
daileifiahoj[1] = 0;
daileifiahoj[2] = 0;
daileifiahoj[3] = ipnoikyhfvsm(&ylalbobacimq->wlujocdbskis, newlbelwshvz, xclzxnzrkvdh);
awafvcglyvyh[0] = -1;
awafvcglyvyh[1] = -1;
awafvcglyvyh[2] = -1;
awafvcglyvyh[3] = newlbelwshvz;
gzeafamodmeb(ylalbobacimq);
qzuszmtpefbs(ylalbobacimq, xclzxnzrkvdh);
qswuykmdmlug(ylalbobacimq);
gefhjoxgjdgt(ylalbobacimq);
spitddtdgatl(ylalbobacimq, ymndlmvtogxm, (const bc7215DataVarPkt_t*)&exhfmkybxmek);
if (altProtocolUsing) { seuhgjhlwgpz.body.msg.fmt = &dayyhlonocwg;
seuhgjhlwgpz.body.msg.datPkt = (bc7215DataVarPkt_t*)&nheotrjqxqej;
return (const bc7215DataVarPkt_t*)&seuhgjhlwgpz;
} else { return (const bc7215DataVarPkt_t*)&nheotrjqxqej;
} } static void wbcduhhgptha(uint8_t gngxjwglbvkk, uint8_t qbocfcxvlfwp) { uint8_t jcaugigjuxpp;
uint8_t kbeujlhwezcc;
uint8_t hgdodzdmndla;
jcaugigjuxpp = gngxjwglbvkk >> 4 ;
kbeujlhwezcc = qbocfcxvlfwp >> 4 ;
hgdodzdmndla = qbocfcxvlfwp&0x0f;
if (kbeujlhwezcc & 0xFC) { kbeujlhwezcc &= 0x03;
hgdodzdmndla += 0x10;
} if ((jcaugigjuxpp < 4) && (kbeujlhwezcc < 4)) { if (awafvcglyvyh[jcaugigjuxpp] == (gngxjwglbvkk&0x0f)) { awafvcglyvyh[kbeujlhwezcc] = hgdodzdmndla;
} } else if ((jcaugigjuxpp < 8) && (kbeujlhwezcc < 4)) { jcaugigjuxpp -= 4;
if (awafvcglyvyh[jcaugigjuxpp] < (gngxjwglbvkk&0x0f)) { awafvcglyvyh[kbeujlhwezcc] = hgdodzdmndla;
} } else if ((jcaugigjuxpp < 12) && (kbeujlhwezcc < 4)) { jcaugigjuxpp -= 8;
if (awafvcglyvyh[jcaugigjuxpp] > (gngxjwglbvkk&0x0f)) { awafvcglyvyh[kbeujlhwezcc] = hgdodzdmndla;
} } } static bool unhdgzknbslk(uint8_t ysvohcihtbrc, const bc7215DataVarPkt_t* dataPktCool25C) { uint16_t zbsbxrmgwhhr;
uint16_t drkbvldzxnru;
const bc7215FormatPkt_t* fmt = NULL;
ylalbobacimq = NULL;
formatLoaded = false;
secFmtLoaded = false;
if ((dataPktCool25C != NULL) && !(ysvohcihtbrc&0x80)) { if (dataPktCool25C->bitLen == 0) { fmt = ((const bc7215CombinedMsg_t*)dataPktCool25C)->body.msg.fmt;
if (fmt != NULL) { dayyhlonocwg = *fmt;
formatLoaded = true;
} dataPktCool25C = ((const bc7215CombinedMsg_t*)dataPktCool25C)->body.msg.datPkt;
if ((fmt == NULL) || (dataPktCool25C == NULL)) { return false;
} } ymndlmvtogxm = ysvohcihtbrc;
exhfmkybxmek.bitLen = dataPktCool25C->bitLen;
drkbvldzxnru = (exhfmkybxmek.bitLen+7)/8;
memcpy(exhfmkybxmek.data, dataPktCool25C->data, drkbvldzxnru);
pasvjyeomvil = -1;
for (zbsbxrmgwhhr=0; zbsbxrmgwhhr<kbyuvmrshpgh; zbsbxrmgwhhr++) {
if (gwtlojdyjddv(zbsbxrmgwhhr)) { pasvjyeomvil = zbsbxrmgwhhr;
return true;
} } } return false;
} static bool ubuixaonhsci(uint8_t juostbfhgyaw, const bc7215CombinedMsg_t hundllzjmjvv[], uint8_t yarepiinyowq) { ylalbobacimq = NULL;
if (hundllzjmjvv[0].body.msg.fmt != NULL) { dayyhlonocwg = *hundllzjmjvv[0].body.msg.fmt;
if (rthpwldrqgbh(juostbfhgyaw, hundllzjmjvv) && fcfezowamxqr(hundllzjmjvv[0].body.msg.datPkt->bitLen, juostbfhgyaw, yarepiinyowq)) { return unhdgzknbslk(dayyhlonocwg.signature.bits.sig, (const bc7215DataVarPkt_t*)&nheotrjqxqej);
} } return false;
} static const bc7215DataVarPkt_t* awqedzxswnbr(int8_t cpudhkuyzttv, int8_t evqflvjabnyp, int8_t exmdjjzytohq, int8_t ckfkxrimjrfl) { bool tmpProtocolUsing;
uint8_t jcrmavnazlar;
uint8_t pnklibodyrgj;
const struct vsghnouiwbyk* mjtbuhyzuuvb;
tmpProtocolUsing = false;
mjtbuhyzuuvb = ylalbobacimq;
if ((ckfkxrimjrfl == KEY_MODE) && (ylalbobacimq->rozfsolwsfzh.mcddolhbanax&0x20)) { ylalbobacimq = &((const struct sxpegamfsrfd*)ylalbobacimq->rozfsolwsfzh.hgdodzdmndla)->cssjkjaqtock;
tmpProtocolUsing = true;
} else if (((ckfkxrimjrfl == KEY_PLUS) || (ckfkxrimjrfl == KEY_MINUS)) && (ylalbobacimq->urotzxmebdry.mcddolhbanax&0x20)) { ylalbobacimq = &((const struct sxpegamfsrfd*)ylalbobacimq->urotzxmebdry.hgdodzdmndla)->cssjkjaqtock;
tmpProtocolUsing = true;
} else if ((ckfkxrimjrfl == KEY_FAN) && (ylalbobacimq->ofajzwessiol.mcddolhbanax&0x20)) { ylalbobacimq = &((const struct sxpegamfsrfd*)ylalbobacimq->ofajzwessiol.hgdodzdmndla)->cssjkjaqtock;
tmpProtocolUsing = true;
} if (tmpProtocolUsing) { eokpcvziyoim = exhfmkybxmek;
if (!bc7215_ac_replace_base(umynxtxlzfya, (const bc7215DataVarPkt_t*)&ojsszplvqtdq)) { return NULL;
} } awafvcglyvyh[0] = cpudhkuyzttv;
awafvcglyvyh[1] = evqflvjabnyp;
awafvcglyvyh[2] = exmdjjzytohq;
awafvcglyvyh[3] = ckfkxrimjrfl;
if (ylalbobacimq != NULL) { if (!ylalbobacimq->spec.scedlvelzavc) { jcrmavnazlar = ylalbobacimq->urjrhromzium->set.tqcqagtvxxob;
pnklibodyrgj = ylalbobacimq->urjrhromzium->set.fpledlehjcsb;
wbcduhhgptha(jcrmavnazlar, pnklibodyrgj);
jcrmavnazlar = ylalbobacimq->urjrhromzium->set.nqsbunmitfrc;
pnklibodyrgj = ylalbobacimq->urjrhromzium->set.wtivyemmzoju;
wbcduhhgptha(jcrmavnazlar, pnklibodyrgj);
jcrmavnazlar = ylalbobacimq->urjrhromzium->set.pllehvocejgu;
pnklibodyrgj = ylalbobacimq->urjrhromzium->set.trwurmhtrcaw;
wbcduhhgptha(jcrmavnazlar, pnklibodyrgj);
} daileifiahoj[0] = 0;
daileifiahoj[1] = 0;
daileifiahoj[2] = 0;
daileifiahoj[3] = 0;
if (awafvcglyvyh[0] >= 0) { daileifiahoj[0] = ipnoikyhfvsm(&ylalbobacimq->urotzxmebdry, awafvcglyvyh[0], xclzxnzrkvdh);
} if ((awafvcglyvyh[1] >= 0) && (awafvcglyvyh[1]<0x0f)) { daileifiahoj[1] = ipnoikyhfvsm(&ylalbobacimq->rozfsolwsfzh, awafvcglyvyh[1], xclzxnzrkvdh);
if (ylalbobacimq->rozfsolwsfzh.mcddolhbanax & 0x80) { awafvcglyvyh[3] = awafvcglyvyh[1];
} } if ((awafvcglyvyh[2] >= 0) && (awafvcglyvyh[2] < 0x0f)) { daileifiahoj[2] = ipnoikyhfvsm(&ylalbobacimq->ofajzwessiol, awafvcglyvyh[2], xclzxnzrkvdh);
if (ylalbobacimq->ofajzwessiol.mcddolhbanax & 0x80) { awafvcglyvyh[3] = awafvcglyvyh[2];
} } if ((awafvcglyvyh[3] >= 0) && (awafvcglyvyh[3]<0x0f)) { daileifiahoj[3] = ipnoikyhfvsm(&ylalbobacimq->wlujocdbskis, awafvcglyvyh[3], xclzxnzrkvdh);
} if (ylalbobacimq->urjrhromzium->set.rvrkwqgflpkv != NULL) { gzeafamodmeb(ylalbobacimq);
} qzuszmtpefbs(ylalbobacimq, xclzxnzrkvdh);
qswuykmdmlug(ylalbobacimq);
gefhjoxgjdgt(ylalbobacimq);
if (tmpProtocolUsing) { ylalbobacimq = mjtbuhyzuuvb;
if (!bc7215_ac_replace_base(ymndlmvtogxm, (const bc7215DataVarPkt_t*)&eokpcvziyoim)) { return NULL;
} if (secFmtLoaded) { seuhgjhlwgpz.body.msg.fmt = &tuptfpuregsc;
seuhgjhlwgpz.body.msg.datPkt = (bc7215DataVarPkt_t*)&nheotrjqxqej;
return (const bc7215DataVarPkt_t*)&seuhgjhlwgpz;
} } if (altProtocolUsing) { seuhgjhlwgpz.body.msg.fmt = &dayyhlonocwg;
seuhgjhlwgpz.body.msg.datPkt = (bc7215DataVarPkt_t*)&nheotrjqxqej;
return (const bc7215DataVarPkt_t*)&seuhgjhlwgpz;
} else { return (const bc7215DataVarPkt_t*)&nheotrjqxqej;
} } else { return  NULL;
} } const char* bc7215_ac_get_ver(void) { return VERSION;
} bool bc7215_ac_init(uint8_t ysvohcihtbrc, const bc7215DataVarPkt_t* dataPktCool25C) { fahrenheitInit = false;
return unhdgzknbslk(ysvohcihtbrc, dataPktCool25C);
} bool bc7215_ac_init_f(uint8_t ysvohcihtbrc, const bc7215DataVarPkt_t* cuvimoscpwjs) { fahrenheitInit = true;
return unhdgzknbslk(ysvohcihtbrc, cuvimoscpwjs);
} bool bc7215_ac_init2(uint8_t juostbfhgyaw, const bc7215CombinedMsg_t hundllzjmjvv[], uint8_t yarepiinyowq) { fahrenheitInit = false;
return ubuixaonhsci(juostbfhgyaw, hundllzjmjvv, yarepiinyowq);
} bool bc7215_ac_init2_f(uint8_t juostbfhgyaw, const bc7215CombinedMsg_t hundllzjmjvv[], uint8_t yarepiinyowq) { fahrenheitInit = true;
return ubuixaonhsci(juostbfhgyaw, hundllzjmjvv, yarepiinyowq);
} bool bc7215_ac_find_next(void) { uint16_t zbsbxrmgwhhr;
if (pasvjyeomvil >= 0) { if (altProtocolUsing) { rfbtqpwrfskw();
altProtocolUsing = false;
} else if (((ylalbobacimq->wlujocdbskis.mcddolhbanax&0xf0) == 0x80) && formatLoaded) { obnxqalbogab(ylalbobacimq);
return true;
} else if ((ylalbobacimq->wlujocdbskis.mcddolhbanax&0xf0) == 0xe0) { altProtocolUsing = true;
return true;
} for (zbsbxrmgwhhr=pasvjyeomvil+1; zbsbxrmgwhhr<kbyuvmrshpgh; zbsbxrmgwhhr++)
{ if (gwtlojdyjddv(zbsbxrmgwhhr)) { pasvjyeomvil = zbsbxrmgwhhr;
return true;
} } } pasvjyeomvil = -1;
ylalbobacimq = NULL;
return false;
} const bc7215DataVarPkt_t* bc7215_ac_set(int8_t mdnpbfaooanr, int8_t evqflvjabnyp, int8_t exmdjjzytohq, int8_t ckfkxrimjrfl) { if (mdnpbfaooanr > 14) { mdnpbfaooanr = -1;
} if (evqflvjabnyp > MODE_FAN) { evqflvjabnyp = -1;
} if (exmdjjzytohq > FAN_HIGH) { exmdjjzytohq = -1;
} if (ckfkxrimjrfl > KEY_FAN) { ckfkxrimjrfl = -1;
} return awqedzxswnbr(mdnpbfaooanr, evqflvjabnyp, exmdjjzytohq, ckfkxrimjrfl);
} const bc7215DataVarPkt_t* bc7215_ac_set_f(int8_t ncpzpizkzeve, int8_t evqflvjabnyp, int8_t exmdjjzytohq, int8_t ckfkxrimjrfl) { uint8_t	mdnpbfaooanr;
if (evqflvjabnyp > MODE_FAN) { evqflvjabnyp = -1;
} if (exmdjjzytohq > FAN_HIGH) { exmdjjzytohq = -1;
} if (ckfkxrimjrfl > KEY_FAN) { ckfkxrimjrfl = -1;
} if ((ncpzpizkzeve < 0) || (ncpzpizkzeve > 28)) { mdnpbfaooanr = -1;
} else { if (ylalbobacimq->nhaqybpfptll != NULL) { mdnpbfaooanr = ylalbobacimq->nhaqybpfptll->iqhduifjeusb[ncpzpizkzeve];
edebutywnedh(&ylalbobacimq->nhaqybpfptll->vzkqjiprdpjc, ncpzpizkzeve, xclzxnzrkvdh);
} else { mdnpbfaooanr = ghgjjuztaesj.iqhduifjeusb[ncpzpizkzeve];
} } return awqedzxswnbr(mdnpbfaooanr, evqflvjabnyp, exmdjjzytohq, ckfkxrimjrfl);
} const bc7215DataVarPkt_t* bc7215_ac_on(void) { uint16_t tldyphszjwnc;
const uint8_t*	qggtibxkwbxd;
if (pasvjyeomvil >= 0) { if (ylalbobacimq->spec.ymmnbayvgjbe) { qggtibxkwbxd = (const uint8_t*)ylalbobacimq->lzjiegmlwhzf.jylyhhlxgchq;
iukuxevqncnf.bitLen = ((*(qggtibxkwbxd+1))<<8)+*qggtibxkwbxd;
if (iukuxevqncnf.bitLen != 0) { tldyphszjwnc = (iukuxevqncnf.bitLen+7)/8+2;
qggtibxkwbxd = qggtibxkwbxd+tldyphszjwnc;
if ((*qggtibxkwbxd != 0) || (*(qggtibxkwbxd+1) != 0)) { iukuxevqncnf.bitLen = ((*(qggtibxkwbxd+1))<<8)+*qggtibxkwbxd;
memcpy(&iukuxevqncnf.data, qggtibxkwbxd+2, (iukuxevqncnf.bitLen+7)/8);
if (altProtocolUsing) { seuhgjhlwgpz.bitLen = 0;
seuhgjhlwgpz.body.msg.fmt = &dayyhlonocwg;
seuhgjhlwgpz.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&iukuxevqncnf);
return (const bc7215DataVarPkt_t*)&seuhgjhlwgpz;
} else { return (const bc7215DataVarPkt_t*)(&iukuxevqncnf);
} } } else { qggtibxkwbxd += 2;
memcpy(&zakxuesnfusb, qggtibxkwbxd, 33);
qggtibxkwbxd += 33;
iukuxevqncnf.bitLen = ((*(qggtibxkwbxd+1))<<8)+*qggtibxkwbxd;
tldyphszjwnc = (iukuxevqncnf.bitLen+7)/8+2;
qggtibxkwbxd += tldyphszjwnc;
iukuxevqncnf.bitLen = ((*(qggtibxkwbxd+1))<<8)+*qggtibxkwbxd;
if (iukuxevqncnf.bitLen != 0) { memcpy(&iukuxevqncnf.data, qggtibxkwbxd+2, (iukuxevqncnf.bitLen+7)/8);
seuhgjhlwgpz.bitLen = 0;
seuhgjhlwgpz.body.msg.fmt = &zakxuesnfusb;
seuhgjhlwgpz.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&iukuxevqncnf);
return (const bc7215DataVarPkt_t*)&seuhgjhlwgpz;
} } } else if (ylalbobacimq->spec.cmdkwamqxjvi || (!((ylalbobacimq->urotzxmebdry.mcddolhbanax | ylalbobacimq->rozfsolwsfzh.mcddolhbanax | ylalbobacimq->ofajzwessiol.mcddolhbanax)&0x80) && (ylalbobacimq->wlujocdbskis.hgdodzdmndla != NULL))) { return rjnjgrjfaldn(5);
} } return NULL;
} const bc7215DataVarPkt_t* bc7215_ac_off(void) { const uint8_t*	qggtibxkwbxd;
if (pasvjyeomvil >= 0) { if (!ylalbobacimq->spec.ymmnbayvgjbe) { return rjnjgrjfaldn(4);
} else { qggtibxkwbxd = (const uint8_t*)ylalbobacimq->lzjiegmlwhzf.jylyhhlxgchq;
iukuxevqncnf.bitLen = ((*(qggtibxkwbxd+1))<<8)+*qggtibxkwbxd;
if (iukuxevqncnf.bitLen != 0) { memcpy(&iukuxevqncnf.data, qggtibxkwbxd+2, (iukuxevqncnf.bitLen+7)/8);
if (altProtocolUsing) { seuhgjhlwgpz.bitLen = 0;
seuhgjhlwgpz.body.msg.fmt = &dayyhlonocwg;
seuhgjhlwgpz.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&iukuxevqncnf);
return (const bc7215DataVarPkt_t*)&seuhgjhlwgpz;
} else { return (const bc7215DataVarPkt_t*)(&iukuxevqncnf);
} } else { qggtibxkwbxd += 2;
memcpy(&zakxuesnfusb, qggtibxkwbxd, 33);
qggtibxkwbxd += 33;
iukuxevqncnf.bitLen = ((*(qggtibxkwbxd+1))<<8)+*qggtibxkwbxd;
memcpy(&iukuxevqncnf.data, qggtibxkwbxd+2, (iukuxevqncnf.bitLen+7)/8);
if (iukuxevqncnf.bitLen != 0) { seuhgjhlwgpz.bitLen = 0;
seuhgjhlwgpz.body.msg.fmt = &zakxuesnfusb;
seuhgjhlwgpz.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&iukuxevqncnf);
return (const bc7215DataVarPkt_t*)&seuhgjhlwgpz;
} } } } return NULL;
} uint8_t bc7215_ac_predefined_cnt(void) { return kqhvphdpbtpb;
} const bc7215DataVarPkt_t* bc7215_ac_predefined_data(uint8_t bjgtqlsnlzdk) { const uint8_t* qggtibxkwbxd;
if (bjgtqlsnlzdk < kqhvphdpbtpb) { qggtibxkwbxd = (const uint8_t*)shnklcxaqppa[bjgtqlsnlzdk];
iukuxevqncnf.bitLen = ((*(qggtibxkwbxd+1))<<8)+*qggtibxkwbxd;
memcpy(&iukuxevqncnf.data, qggtibxkwbxd+2, (iukuxevqncnf.bitLen+7)/8);
return (const bc7215DataVarPkt_t*)&iukuxevqncnf;
} else { return NULL;
} } const bc7215DataVarPkt_t* bc7215_ac_predefined_data_f(uint8_t bjgtqlsnlzdk) { const uint8_t* qggtibxkwbxd;
if (bjgtqlsnlzdk < kqhvphdpbtpb) { qggtibxkwbxd = (const uint8_t*)kwniwryzbdqn[bjgtqlsnlzdk];
iukuxevqncnf.bitLen = ((*(qggtibxkwbxd+1))<<8)+*qggtibxkwbxd;
memcpy(&iukuxevqncnf.data, qggtibxkwbxd+2, (iukuxevqncnf.bitLen+7)/8);
return (const bc7215DataVarPkt_t*)&iukuxevqncnf;
} else { return NULL;
} } const bc7215FormatPkt_t* bc7215_ac_predefined_fmt(uint8_t bjgtqlsnlzdk) { if (bjgtqlsnlzdk < kqhvphdpbtpb) { memcpy(&zakxuesnfusb, ((const uint8_t*)&zpmezqzipprw)+33*bjgtqlsnlzdk, 33);
return &zakxuesnfusb;
} else { return NULL;
} } const char* bc7215_ac_predefined_name(uint8_t bjgtqlsnlzdk) { if (bjgtqlsnlzdk < kqhvphdpbtpb) { return PREDEFINDED_NAMES[bjgtqlsnlzdk];
} else { return "";
} } uint8_t bc7215_ac_need_extra_sample(void) { uint8_t dskbycvacpfu;
dskbycvacpfu = 0;
if (ylalbobacimq != NULL) { if (ylalbobacimq->urotzxmebdry.mcddolhbanax&0x20) { dskbycvacpfu = 1;
} if (ylalbobacimq->rozfsolwsfzh.mcddolhbanax&0x20) { dskbycvacpfu = 2;
} if (ylalbobacimq->ofajzwessiol.mcddolhbanax&0x20) { dskbycvacpfu = 3;
} if (((ylalbobacimq->wlujocdbskis.mcddolhbanax&0xf0) == 0xc0) ||(altProtocolUsing && ((ylalbobacimq->wlujocdbskis.mcddolhbanax&0xf0) == 0xe0))) { dskbycvacpfu = 4;
} } return dskbycvacpfu;
} bool bc7215_ac_save_2nd_base(uint8_t ysvohcihtbrc, const bc7215CombinedMsg_t* message) { uint8_t drkbvldzxnru;
if (!(ysvohcihtbrc&0x80) && (message->body.msg.fmt->signature.bits.sig == (ysvohcihtbrc&0x3f))) { drkbvldzxnru = (message->body.msg.datPkt->bitLen+7)/8;
if (drkbvldzxnru <= BC7215_MAX_RX_DATA_SIZE) { tuptfpuregsc = *message->body.msg.fmt;
secFmtLoaded = true;
umynxtxlzfya = ysvohcihtbrc;
ojsszplvqtdq.bitLen = message->body.msg.datPkt->bitLen;
memcpy(ojsszplvqtdq.data, message->body.msg.datPkt->data, drkbvldzxnru);
return true;
} } return false;
} bc7215CombinedMsg_t bc7215_ac_get_2nd_base(void) { bc7215CombinedMsg_t ixvlmpzwrwin;
ixvlmpzwrwin.bitLen = 0;
ixvlmpzwrwin.body.msg.datPkt = (bc7215DataVarPkt_t*)&ojsszplvqtdq;
ixvlmpzwrwin.body.msg.fmt = &tuptfpuregsc;
return ixvlmpzwrwin;
} bool bc7215_ac_replace_base(uint8_t ysvohcihtbrc, const bc7215DataVarPkt_t* wkoutktpiwol) { uint8_t drkbvldzxnru;
if ((ylalbobacimq != NULL) && (wkoutktpiwol != NULL) && (wkoutktpiwol->bitLen <= BC7215_MAX_RX_DATA_SIZE*8)) { if (wkoutktpiwol->bitLen != 0) { if (!(ysvohcihtbrc&0x80)) { ymndlmvtogxm = ysvohcihtbrc;
drkbvldzxnru = (wkoutktpiwol->bitLen+7)/8;
memcpy(exhfmkybxmek.data, wkoutktpiwol->data, drkbvldzxnru);
exhfmkybxmek.bitLen = wkoutktpiwol->bitLen;
} else { return false;
} } else if (ysvohcihtbrc < 4) { rthpwldrqgbh(ysvohcihtbrc, (const bc7215CombinedMsg_t*) wkoutktpiwol);
ymndlmvtogxm = dayyhlonocwg.signature.bits.sig;
exhfmkybxmek = nheotrjqxqej;
} else { return false;
} spitddtdgatl(ylalbobacimq, ymndlmvtogxm, (const bc7215DataVarPkt_t*)&exhfmkybxmek);
return true;
} else { return false;
} } const bc7215FormatPkt_t* bc7215_ac_get_base_fmt(void) { return &dayyhlonocwg;
} const bc7215DataVarPkt_t* bc7215_ac_get_base_data(void) { return (bc7215DataVarPkt_t*)&exhfmkybxmek;
} bool bc7215_ac_parse(int8_t* cpudhkuyzttv, int8_t* evqflvjabnyp, int8_t* exmdjjzytohq, int8_t* bgohuvkfgymw) { bool dskbycvacpfu = false;
*cpudhkuyzttv = -1;
*evqflvjabnyp = -1;
*exmdjjzytohq = -1;
*bgohuvkfgymw = -1;
if (!pktLenChanged) { dskbycvacpfu = qzuszmtpefbs(ylalbobacimq, dieecgizrxee);
if (dskbycvacpfu) { *cpudhkuyzttv = gvmzfeyguymh(&ylalbobacimq->urotzxmebdry, 15);
*evqflvjabnyp = gvmzfeyguymh(&ylalbobacimq->rozfsolwsfzh, 5);
*exmdjjzytohq = gvmzfeyguymh(&ylalbobacimq->ofajzwessiol, 4);
*bgohuvkfgymw = iznnydsjihel(ylalbobacimq);
} } return dskbycvacpfu;
} bool bc7215_ac_parse_f(int8_t* ncpzpizkzeve, int8_t* evqflvjabnyp, int8_t* exmdjjzytohq, int8_t* bgohuvkfgymw) { bool dskbycvacpfu;
dskbycvacpfu = bc7215_ac_parse(ncpzpizkzeve, evqflvjabnyp, exmdjjzytohq, bgohuvkfgymw);
if (dskbycvacpfu && (*ncpzpizkzeve >= 0)) { if (ylalbobacimq->nhaqybpfptll != NULL) { *ncpzpizkzeve = wgocioibmpsi(ylalbobacimq->nhaqybpfptll);
} else { *ncpzpizkzeve = wgocioibmpsi(&ghgjjuztaesj);
} } return dskbycvacpfu;
}