#include "bc7215_ac_lib.h"
#include <string.h>
#define zyydpgxliaif  0
#define vcabqkuncaai   1
struct jzrjinarvghn;
struct tscdjwilqjwi;
struct oebbqnqfnloq;
struct mqbafetntzql;
struct ebbynksakqwk;
union pcyrpcjthqnx;
static void yxrpjuurrlvu(const struct oebbqnqfnloq* enbbaqhuguke);
static void drrrdscymaou(const struct jzrjinarvghn* mfziljnihjsa);
static void awsteilqqidy(const struct jzrjinarvghn* mfziljnihjsa);
static void zlgfxmvzkalt(uint8_t nqjsrsnaymrk[][BC7215_MAX_RX_DATA_SIZE], bc7215DataVarPkt_t* ejlhruakwgum, const struct jzrjinarvghn* mfziljnihjsa);
static void mcftdsxoagub(const struct jzrjinarvghn* mfziljnihjsa);
static uint8_t uurdlftbhnrr(uint8_t byte);
static void yqmyeoglvjxv(const struct jzrjinarvghn* mfziljnihjsa, bc7215DataVarPkt_t* ejlhruakwgum);
static bool cobiupqigoqa(const bc7215DataVarPkt_t* bvyweglqjedh);
static bc7215DataMaxPkt_t	sapcqlhnefas;
static bc7215DataMaxPkt_t	jzrbzxjvujig;
static bc7215DataMaxPkt_t	ziciuqwubgaa;
static bc7215DataMaxPkt_t	wqwpsggznumr;
static bc7215DataMaxPkt_t	kjqjwbcmhzpv;
static bc7215FormatPkt_t	pivgeeqvhhpr;
static bc7215FormatPkt_t   iaketlgrgirb;
static bc7215FormatPkt_t   rjzhjhfplwrl;
static bc7215FormatPkt_t	xcjltbzvwjof;
static uint8_t dzsumcvcsfvg[4][BC7215_MAX_RX_DATA_SIZE];
static uint8_t ullmnppxxckm[4][BC7215_MAX_RX_DATA_SIZE];
static int16_t wiznxuyrkzhr = -1;
static uint8_t tjmnkrnjmplx;
static uint8_t mhiohwhuizkc;
static uint8_t bvtbmjubhgxm;
static struct oebbqnqfnloq* htztnpskwcvl;
static uint8_t ykfwzrfuvamm[4];
static int8_t kuisskbiyanl[4];
static bc7215CombinedMsg_t qanfaymkryfx = {0,{.msg={.fmt=NULL, .datPkt=NULL}}};
static const struct jzrjinarvghn* envgkvyuvctc;
static bool tyxuvftnzciv;
static bool domyebqqxybm;
static bool lyoruyqupvgk;
static bool pfipaetctpwp = false;
static bool ldyzjyfsozom;
static bool vbsdeujddnxr;
static uint8_t xcqbznndjhij = 25;
static uint8_t flslgruxmtxo = 78;
int msg, pnum;
static const uint8_t xdfisseiufld[8] = { 0xff, 0x01, 0x03, 0x07, 0x0f, 0x1f, 0x3f, 0x7f };
static const uint8_t qafpuptaxgyf[8] = { 0xff, 0x80, 0xc0, 0xe0, 0xf0, 0xf8, 0xfc, 0xfe };
static const uint8_t yjkmododoujl[4] = { 0x03, 0x0c, 0x30, 0xc0 };
static const uint8_t gjpklnywlizj[8] = { 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80 };
static const uint8_t qpewgelzvrjj[16] = { 0x00, 0x02, 0x01, 0x03, 0x08, 0x0a, 0x09, 0x0b, 0x04, 0x06, 0x05, 0x07, 0x0c, 0x0e, 0x0d, 0x0f };
static const uint8_t dtzcgmqmhfdd[16] = { 0, 0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07, 0x0f };
static const uint8_t xmmubavfmyxo[16] = { 0, 0x01, 0x01, 0x02, 0x01, 0x02, 0x02, 0x03, 0x01, 0x02, 0x02, 0x03, 0x02, 0x03, 0x03, 0x04 };
typedef struct mqbafetntzql { uint8_t		mopbcjzgmcja;
uint8_t		kuaqjbcvpyes;
uint8_t		zlrtbaktlyzx;
uint8_t		lzcfsjwbnffw;
const uint8_t*	ytlcwydutkha;
} mqbafetntzql;
typedef struct ebbynksakqwk { uint8_t     ckqgxozywxmq;
uint8_t     mopbcjzgmcja;
uint8_t     kuaqjbcvpyes;
uint8_t     zlrtbaktlyzx;
const uint8_t*    rdoojlcaxsdk;
} ebbynksakqwk;
typedef union pcyrpcjthqnx { struct { uint8_t		tgrplbauzqqq;
uint8_t		keodtzzroqbd;
uint8_t		okquusoiarbp;
uint8_t		mzgkhzfchxtc;
uint8_t		pkpooopfmkrs;
uint8_t		fcvaxtjopotg;
const ebbynksakqwk*  nyqmexqqqjzu;
} set;
struct { uint8_t		pqggajptaolh;
uint8_t		wcuouwgtpvbg;
uint8_t		qeasospjtadu;
uint8_t		fwrbecujebtv;
} tihyumdayysw;
} pcyrpcjthqnx;
#ifndef _NO_DEPRECATED
struct opvdfjyhetkm { const ebbynksakqwk*		zogvzqcdcrgi;
const struct jzrjinarvghn*	mfziljnihjsa;
uint8_t 	uunzwbskiucw;
uint8_t		dvfxpcvcjsdb;
};
#endif
struct hupxupixhngz { uint8_t		uzmxwkhdlkjl;
uint8_t 	kuaqjbcvpyes;
uint8_t		bits;
};
struct smyuzdtplpcq { struct { uint8_t	   tuxqdptrerhp : 4;
uint8_t		uzmxwkhdlkjl : 4;
} nqjsrsnaymrk;
uint8_t 	kuaqjbcvpyes;
uint8_t		bits;
};
typedef void (*setExtBase_t)(const bc7215DataVarPkt_t* , const bc7215FormatPkt_t*);
union offBits_t { struct { struct smyuzdtplpcq  oeiaiwqhculr;
struct smyuzdtplpcq  cuoycwtsmtjr;
} buhyvlrkmues;
const bc7215DataVarPkt_t* bvyweglqjedh;
const bc7215CombinedMsg_t*      qviegizrbzco;
const setExtBase_t		xhwercrymuhm;
};
struct oebbqnqfnloq { uint8_t		ixvdbojkppfu;
uint8_t		mpqeiytncxnk;
int8_t		rcgwtdbxudzi;
uint8_t		gudbfecopxko;
struct { uint8_t		uzmxwkhdlkjl : 5;
uint8_t    bxoakywcgcxr : 1;
uint8_t		byte : 1;
uint8_t     enstmanatybz  : 1;
} uzmxwkhdlkjl;
int8_t		mgpzgiotmdzg;
int8_t		fbrvysdlrmrf;
uint8_t		vwagvwljhtrt;
uint8_t		yvnopioecdgf;
};
typedef bool (*algorithm_t)(const struct jzrjinarvghn* mfziljnihjsa, const struct oebbqnqfnloq* enbbaqhuguke, bool hiukkmirrlxz);
struct tscdjwilqjwi { algorithm_t xbjpducmipqs;
const struct oebbqnqfnloq* enbbaqhuguke;
};
struct ldftspiijtra { const int8_t*	iezimrbuhymx;
mqbafetntzql			wwoykbnvyqzp;
};
struct jzrjinarvghn { struct { uint8_t jsohiapiyung  : 1;
uint8_t jgqqdcjvtzmb : 1;
uint8_t    meugerfooagb : 1;
uint8_t      vrpqfnokrnbi : 1;
uint8_t  mvpxvriwlnzh : 1;
uint8_t jkzmicqrmkcx : 1;
uint8_t  duydkrzywxnm : 1;
} spec;
uint8_t  signature;
uint16_t bitLen;
uint16_t tihyumdayysw[4];
mqbafetntzql  lkytgmwsvbjc;
mqbafetntzql  zagbhfvgdmex;
mqbafetntzql  efzkaswlxsjp;
mqbafetntzql  jyzhocqchyzz;
const pcyrpcjthqnx*  lbtdeitxhjhh;
union offBits_t	tbqxbwmytmil;
const struct tscdjwilqjwi* xvskvavzjiht;
const struct ldftspiijtra*	fihqcdjkaqjh;
};
struct mnbpqhzlmcjq { struct jzrjinarvghn	mfziljnihjsa;
const void* 				zogvzqcdcrgi;
};
static uint8_t uurdlftbhnrr(uint8_t byte);
static void uepqnkyltcbw(const struct jzrjinarvghn* mfziljnihjsa);
static bool giokrvdulifd(const struct jzrjinarvghn* mfziljnihjsa);
static uint8_t obnjhpmwwuvt(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return rbirkyzeygaf+ykjhqoilfycf;
} static uint8_t duivswunwliu(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return rbirkyzeygaf^ykjhqoilfycf;
} static uint8_t myugatdwhxqs(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return rbirkyzeygaf&ykjhqoilfycf;
} static uint8_t qthvqeomlhdu(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return rbirkyzeygaf|ykjhqoilfycf;
} static uint8_t gtgssananthb(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return ykjhqoilfycf<<rbirkyzeygaf;
} static uint8_t qlgrentqpixv(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return ykjhqoilfycf>>rbirkyzeygaf;
} static uint8_t tmvwkxyjonrg(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return rbirkyzeygaf-ykjhqoilfycf;
} static uint8_t xsqjoxiodald(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { uint8_t duygcdtehlne = ((ykjhqoilfycf&0x0f)+(ykjhqoilfycf>>4))&0x0f;
if (duygcdtehlne & 0x08) { duygcdtehlne |= 0xf0;
} return rbirkyzeygaf+duygcdtehlne;
} static uint8_t bgscppzsunyx(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { (void)rbirkyzeygaf;
return ykjhqoilfycf;
} static uint8_t dtuesxzqfgjb(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return rbirkyzeygaf&(~ykjhqoilfycf);
} static uint8_t jobxgfdwfqsu (uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return ((rbirkyzeygaf&0xf0)+(ykjhqoilfycf&0xf0)) | ((rbirkyzeygaf+ykjhqoilfycf)&0x0f);
} static uint8_t chultxkxtuxf(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return rbirkyzeygaf+uurdlftbhnrr(ykjhqoilfycf);
} static uint8_t peohmrttwkhg(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return rbirkyzeygaf-uurdlftbhnrr(ykjhqoilfycf);
} static uint8_t xkzhufcrlwth(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { return rbirkyzeygaf+xmmubavfmyxo[ykjhqoilfycf>>4]+xmmubavfmyxo[ykjhqoilfycf&0x0f];
} static uint8_t yfzigzagesek(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { (void)ykjhqoilfycf;
return ~rbirkyzeygaf;
} static uint8_t gsotilbmzwml(uint8_t rbirkyzeygaf, uint8_t ykjhqoilfycf) { (void)rbirkyzeygaf;
return (ykjhqoilfycf<<4)|(ykjhqoilfycf>>4);
} typedef uint8_t (*calFunc_t)(uint8_t, uint8_t);
static const calFunc_t psrggqspjmka[] = { obnjhpmwwuvt, duivswunwliu, myugatdwhxqs, qthvqeomlhdu, gtgssananthb, qlgrentqpixv, tmvwkxyjonrg, xsqjoxiodald, bgscppzsunyx, dtuesxzqfgjb, jobxgfdwfqsu, chultxkxtuxf, peohmrttwkhg, xkzhufcrlwth, yfzigzagesek, gsotilbmzwml };
static uint8_t nmjtzdikdhpl(uint8_t nqjsrsnaymrk, uint8_t kuaqjbcvpyes) { if (kuaqjbcvpyes&0x01) { return dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2]&0x0f;
} else { return dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2]>>4;
} } static void xdttdyorxuoe(uint8_t nqjsrsnaymrk, uint8_t kuaqjbcvpyes, uint8_t data) { data &= 0x0f;
if (kuaqjbcvpyes&0x01) { dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2] = (dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2]&0xf0)|data;
} else { dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2] = (dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2]&0x0f) | (data<<4);
} } static uint8_t zalyzeeuybds(uint8_t nqjsrsnaymrk, uint8_t kuaqjbcvpyes) { if (kuaqjbcvpyes&0x01) { return dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2]>>4;
} else { return dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2]&0x0f;
} } static void pcroxlqnrxob(uint8_t nqjsrsnaymrk, uint8_t kuaqjbcvpyes, uint8_t data) { data &= 0x0f;
if (kuaqjbcvpyes&0x01) { dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2] = (dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2]&0x0f) | (data<<4);
} else { dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2] = (dzsumcvcsfvg[nqjsrsnaymrk][kuaqjbcvpyes/2]&0xf0)|data;
} } static bool rstxotzjflzs(const struct jzrjinarvghn* mfziljnihjsa, const struct oebbqnqfnloq* enbbaqhuguke, bool hiukkmirrlxz) { uint8_t nqjsrsnaymrk, ghkcctcgdsls, otihgeqjidfo, nibStart, nibEnd;
uint8_t zwkeegcjawso;
uint8_t rbirkyzeygaf, ykjhqoilfycf;
uint8_t vmjindlfsbxu;
uint8_t mgpzgiotmdzg, targetPos;
ghkcctcgdsls = enbbaqhuguke->ixvdbojkppfu>>4;
otihgeqjidfo = enbbaqhuguke->ixvdbojkppfu&0x0f;
mgpzgiotmdzg = enbbaqhuguke->mgpzgiotmdzg&0x03;
nqjsrsnaymrk = ghkcctcgdsls;
if (enbbaqhuguke->uzmxwkhdlkjl.bxoakywcgcxr) { vmjindlfsbxu = bvtbmjubhgxm;
} else { vmjindlfsbxu = 0;
} while (nqjsrsnaymrk <= otihgeqjidfo) { if (nqjsrsnaymrk == ghkcctcgdsls) { nibStart = enbbaqhuguke->mpqeiytncxnk;
} else { nibStart = 0;
} if (nqjsrsnaymrk == otihgeqjidfo) { nibEnd = ((mfziljnihjsa->tihyumdayysw[nqjsrsnaymrk]+7)/8)*2-1+enbbaqhuguke->rcgwtdbxudzi;
} else { nibEnd = ((mfziljnihjsa->tihyumdayysw[nqjsrsnaymrk]+7)/8)*2-1;
} for (zwkeegcjawso=nibStart; zwkeegcjawso<=nibEnd; zwkeegcjawso=zwkeegcjawso+enbbaqhuguke->gudbfecopxko) {
ykjhqoilfycf = nmjtzdikdhpl(nqjsrsnaymrk, zwkeegcjawso);
if (enbbaqhuguke->uzmxwkhdlkjl.enstmanatybz) { rbirkyzeygaf = enbbaqhuguke->yvnopioecdgf;
targetPos = zwkeegcjawso+enbbaqhuguke->fbrvysdlrmrf;
vmjindlfsbxu = psrggqspjmka[enbbaqhuguke->uzmxwkhdlkjl.uzmxwkhdlkjl](rbirkyzeygaf, ykjhqoilfycf);
vmjindlfsbxu &= enbbaqhuguke->vwagvwljhtrt;
if (enbbaqhuguke->mgpzgiotmdzg >= 0) { if (hiukkmirrlxz) { vmjindlfsbxu = (nmjtzdikdhpl(mgpzgiotmdzg, targetPos)&(~enbbaqhuguke->vwagvwljhtrt)) | vmjindlfsbxu;
xdttdyorxuoe(mgpzgiotmdzg, targetPos, vmjindlfsbxu);
} else { if ((vmjindlfsbxu&0x0f) != (nmjtzdikdhpl(mgpzgiotmdzg, targetPos)&(enbbaqhuguke->vwagvwljhtrt))) { return false;
} } } } else { rbirkyzeygaf = vmjindlfsbxu;
vmjindlfsbxu = psrggqspjmka[enbbaqhuguke->uzmxwkhdlkjl.uzmxwkhdlkjl](rbirkyzeygaf, ykjhqoilfycf);
} } nqjsrsnaymrk++;
} if (!enbbaqhuguke->uzmxwkhdlkjl.enstmanatybz) { ykjhqoilfycf = vmjindlfsbxu;
rbirkyzeygaf = enbbaqhuguke->yvnopioecdgf;
vmjindlfsbxu = psrggqspjmka[enbbaqhuguke->vwagvwljhtrt](rbirkyzeygaf,ykjhqoilfycf);
bvtbmjubhgxm = vmjindlfsbxu;
if (enbbaqhuguke->mgpzgiotmdzg >= 0) { if (enbbaqhuguke->uzmxwkhdlkjl.byte) { targetPos = (mfziljnihjsa->tihyumdayysw[mgpzgiotmdzg]+7)/8-1+enbbaqhuguke->fbrvysdlrmrf;
if (hiukkmirrlxz) { dzsumcvcsfvg[mgpzgiotmdzg][targetPos] = vmjindlfsbxu;
} else { return vmjindlfsbxu == dzsumcvcsfvg[mgpzgiotmdzg][targetPos];
} } else { targetPos = (mfziljnihjsa->tihyumdayysw[mgpzgiotmdzg]+7)/8*2-1+enbbaqhuguke->fbrvysdlrmrf;
if (hiukkmirrlxz) { xdttdyorxuoe(mgpzgiotmdzg, targetPos, vmjindlfsbxu&0x0f);
} else { return (vmjindlfsbxu&0x0f) == nmjtzdikdhpl(mgpzgiotmdzg, targetPos);
} } } } return true;
} static bool dhkczohuuzns(const struct jzrjinarvghn* mfziljnihjsa, const struct oebbqnqfnloq* enbbaqhuguke, bool hiukkmirrlxz) { uint8_t nqjsrsnaymrk, ghkcctcgdsls, otihgeqjidfo, nibStart, nibEnd;
uint8_t zwkeegcjawso;
uint8_t rbirkyzeygaf, ykjhqoilfycf;
uint8_t vmjindlfsbxu;
uint8_t mgpzgiotmdzg, targetPos;
ghkcctcgdsls = enbbaqhuguke->ixvdbojkppfu>>4;
otihgeqjidfo = enbbaqhuguke->ixvdbojkppfu&0x0f;
mgpzgiotmdzg = enbbaqhuguke->mgpzgiotmdzg&0x03;
nqjsrsnaymrk = ghkcctcgdsls;
if (enbbaqhuguke->uzmxwkhdlkjl.bxoakywcgcxr) { vmjindlfsbxu = bvtbmjubhgxm;
} else { vmjindlfsbxu = 0;
} while (nqjsrsnaymrk <= otihgeqjidfo) { if (nqjsrsnaymrk == ghkcctcgdsls) { nibStart = enbbaqhuguke->mpqeiytncxnk;
} else { nibStart = 0;
} if (nqjsrsnaymrk == otihgeqjidfo) { nibEnd = ((mfziljnihjsa->tihyumdayysw[nqjsrsnaymrk]+7)/8)*2-1+enbbaqhuguke->rcgwtdbxudzi;
} else { nibEnd = ((mfziljnihjsa->tihyumdayysw[nqjsrsnaymrk]+7)/8)*2-1;
} for (zwkeegcjawso=nibStart; zwkeegcjawso<=nibEnd; zwkeegcjawso=zwkeegcjawso+enbbaqhuguke->gudbfecopxko) {
ykjhqoilfycf = zalyzeeuybds(nqjsrsnaymrk, zwkeegcjawso);
if (enbbaqhuguke->uzmxwkhdlkjl.enstmanatybz) { rbirkyzeygaf = enbbaqhuguke->yvnopioecdgf;
targetPos = zwkeegcjawso+enbbaqhuguke->fbrvysdlrmrf;
vmjindlfsbxu = psrggqspjmka[enbbaqhuguke->uzmxwkhdlkjl.uzmxwkhdlkjl](rbirkyzeygaf, ykjhqoilfycf);
vmjindlfsbxu &= enbbaqhuguke->vwagvwljhtrt;
if (enbbaqhuguke->mgpzgiotmdzg >= 0) { if (hiukkmirrlxz) { vmjindlfsbxu = (zalyzeeuybds(mgpzgiotmdzg, targetPos)&(~enbbaqhuguke->vwagvwljhtrt)) | vmjindlfsbxu;
pcroxlqnrxob(mgpzgiotmdzg, targetPos, vmjindlfsbxu);
} else { if (vmjindlfsbxu != (zalyzeeuybds(mgpzgiotmdzg, targetPos)&(enbbaqhuguke->vwagvwljhtrt))) { return false;
} } } } else { rbirkyzeygaf = vmjindlfsbxu;
vmjindlfsbxu = psrggqspjmka[enbbaqhuguke->uzmxwkhdlkjl.uzmxwkhdlkjl](rbirkyzeygaf, ykjhqoilfycf);
} } nqjsrsnaymrk++;
} if (!enbbaqhuguke->uzmxwkhdlkjl.enstmanatybz) { ykjhqoilfycf = vmjindlfsbxu;
rbirkyzeygaf = enbbaqhuguke->yvnopioecdgf;
vmjindlfsbxu = psrggqspjmka[enbbaqhuguke->vwagvwljhtrt](rbirkyzeygaf,ykjhqoilfycf);
bvtbmjubhgxm = vmjindlfsbxu;
if (enbbaqhuguke->mgpzgiotmdzg >= 0) { if (enbbaqhuguke->uzmxwkhdlkjl.byte) { targetPos = (mfziljnihjsa->tihyumdayysw[mgpzgiotmdzg]+7)/8-1+enbbaqhuguke->fbrvysdlrmrf;
if (hiukkmirrlxz) { dzsumcvcsfvg[mgpzgiotmdzg][targetPos] = vmjindlfsbxu;
} else { return vmjindlfsbxu == dzsumcvcsfvg[mgpzgiotmdzg][targetPos];
} } else { targetPos = (mfziljnihjsa->tihyumdayysw[mgpzgiotmdzg]+7)/8*2-1+enbbaqhuguke->fbrvysdlrmrf;
if (hiukkmirrlxz) { pcroxlqnrxob(mgpzgiotmdzg, targetPos, vmjindlfsbxu&0x0f);
} else { return (vmjindlfsbxu&0x0f) == zalyzeeuybds(mgpzgiotmdzg, targetPos);
} } } } return true;
} static bool jydanxgomaxr(const struct jzrjinarvghn* mfziljnihjsa, const struct oebbqnqfnloq* enbbaqhuguke, bool hiukkmirrlxz) { uint8_t nqjsrsnaymrk, ghkcctcgdsls, otihgeqjidfo, byteStart, byteEnd;
uint8_t zwkeegcjawso;
uint8_t rbirkyzeygaf, ykjhqoilfycf;
uint8_t vmjindlfsbxu;
uint8_t mgpzgiotmdzg, targetPos;
ghkcctcgdsls = enbbaqhuguke->ixvdbojkppfu>>4;
otihgeqjidfo = enbbaqhuguke->ixvdbojkppfu&0x0f;
mgpzgiotmdzg = enbbaqhuguke->mgpzgiotmdzg&0x03;
nqjsrsnaymrk = ghkcctcgdsls;
if (enbbaqhuguke->uzmxwkhdlkjl.bxoakywcgcxr) { vmjindlfsbxu = bvtbmjubhgxm;
} else { vmjindlfsbxu = 0;
} while (nqjsrsnaymrk <= otihgeqjidfo) { if (nqjsrsnaymrk == ghkcctcgdsls) { byteStart = enbbaqhuguke->mpqeiytncxnk;
} else { byteStart = 0;
} if (nqjsrsnaymrk == otihgeqjidfo) { byteEnd = (mfziljnihjsa->tihyumdayysw[nqjsrsnaymrk]+7)/8-1+enbbaqhuguke->rcgwtdbxudzi;
} else { byteEnd = (mfziljnihjsa->tihyumdayysw[nqjsrsnaymrk]+7)/8-1;
} for (zwkeegcjawso=byteStart; zwkeegcjawso<=byteEnd; zwkeegcjawso=zwkeegcjawso+enbbaqhuguke->gudbfecopxko) {
ykjhqoilfycf = dzsumcvcsfvg[nqjsrsnaymrk][zwkeegcjawso];
if (enbbaqhuguke->uzmxwkhdlkjl.enstmanatybz) { rbirkyzeygaf = enbbaqhuguke->yvnopioecdgf;
targetPos = zwkeegcjawso+enbbaqhuguke->fbrvysdlrmrf;
vmjindlfsbxu = psrggqspjmka[enbbaqhuguke->uzmxwkhdlkjl.uzmxwkhdlkjl](rbirkyzeygaf, ykjhqoilfycf);
vmjindlfsbxu &= enbbaqhuguke->vwagvwljhtrt;
if (enbbaqhuguke->mgpzgiotmdzg >= 0) { if (hiukkmirrlxz) { vmjindlfsbxu = (dzsumcvcsfvg[mgpzgiotmdzg][targetPos]&(~enbbaqhuguke->vwagvwljhtrt)) | vmjindlfsbxu;
dzsumcvcsfvg[mgpzgiotmdzg][targetPos] = vmjindlfsbxu;
} else { if (vmjindlfsbxu != (dzsumcvcsfvg[mgpzgiotmdzg][targetPos]&(enbbaqhuguke->vwagvwljhtrt))) { return false;
} } } } else { rbirkyzeygaf = vmjindlfsbxu;
vmjindlfsbxu = psrggqspjmka[enbbaqhuguke->uzmxwkhdlkjl.uzmxwkhdlkjl](rbirkyzeygaf, ykjhqoilfycf);
} } nqjsrsnaymrk++;
} if (!enbbaqhuguke->uzmxwkhdlkjl.enstmanatybz) { ykjhqoilfycf = vmjindlfsbxu;
rbirkyzeygaf = enbbaqhuguke->yvnopioecdgf;
vmjindlfsbxu = psrggqspjmka[enbbaqhuguke->vwagvwljhtrt](rbirkyzeygaf,ykjhqoilfycf);
bvtbmjubhgxm = vmjindlfsbxu;
if (enbbaqhuguke->mgpzgiotmdzg >= 0) { targetPos = (mfziljnihjsa->tihyumdayysw[mgpzgiotmdzg]+7)/8-1+enbbaqhuguke->fbrvysdlrmrf;
if (hiukkmirrlxz) { dzsumcvcsfvg[mgpzgiotmdzg][targetPos] = vmjindlfsbxu;
} else { return vmjindlfsbxu == dzsumcvcsfvg[mgpzgiotmdzg][targetPos];
} } } return true;
} static bool fwfrsytcsdqr(const struct jzrjinarvghn* mfziljnihjsa, const struct oebbqnqfnloq* enbbaqhuguke, bool hiukkmirrlxz) { (void)mfziljnihjsa;
if (hiukkmirrlxz) { yxrpjuurrlvu(enbbaqhuguke);
} return true;
} static bool fdeftqqvudxt(const struct jzrjinarvghn* mfziljnihjsa, const struct oebbqnqfnloq* enbbaqhuguke, bool hiukkmirrlxz) { bool vmjindlfsbxu;
struct jzrjinarvghn rgpzmvomlhal;
rgpzmvomlhal.spec = mfziljnihjsa->spec;
rgpzmvomlhal.signature = mfziljnihjsa->signature;
rgpzmvomlhal.bitLen = mfziljnihjsa->bitLen;
rgpzmvomlhal.tihyumdayysw[0] = mfziljnihjsa->lbtdeitxhjhh->tihyumdayysw.pqggajptaolh;
rgpzmvomlhal.tihyumdayysw[1] = mfziljnihjsa->lbtdeitxhjhh->tihyumdayysw.wcuouwgtpvbg;
rgpzmvomlhal.tihyumdayysw[2] = mfziljnihjsa->lbtdeitxhjhh->tihyumdayysw.qeasospjtadu;
rgpzmvomlhal.tihyumdayysw[3] = mfziljnihjsa->lbtdeitxhjhh->tihyumdayysw.fwrbecujebtv;
awsteilqqidy(mfziljnihjsa);
drrrdscymaou(mfziljnihjsa);
yqmyeoglvjxv(&rgpzmvomlhal, (bc7215DataVarPkt_t*)&ziciuqwubgaa);
vmjindlfsbxu = jydanxgomaxr(&rgpzmvomlhal, enbbaqhuguke, hiukkmirrlxz);
awsteilqqidy(&rgpzmvomlhal);
drrrdscymaou(&rgpzmvomlhal);
yqmyeoglvjxv(mfziljnihjsa, (bc7215DataVarPkt_t*)&ziciuqwubgaa);
return vmjindlfsbxu;
}
#ifndef _NO_DEPRECATED
static bool fjadgysdvbag(const struct jzrjinarvghn* mfziljnihjsa, const struct oebbqnqfnloq* enbbaqhuguke, bool hiukkmirrlxz) { uint8_t zwkeegcjawso;
(void)hiukkmirrlxz;
for (zwkeegcjawso=0; zwkeegcjawso<enbbaqhuguke->rcgwtdbxudzi; zwkeegcjawso++)
{ if (dzsumcvcsfvg[enbbaqhuguke->ixvdbojkppfu][enbbaqhuguke->mpqeiytncxnk+zwkeegcjawso] != *(mfziljnihjsa->efzkaswlxsjp.ytlcwydutkha+zwkeegcjawso)) { return false;
} } return true;
}
#endif
static void lsdnufbscnyj(const bc7215DataVarPkt_t* lcuzakjvlswm, const bc7215FormatPkt_t* yvflzmlmvjhm) { (void)lcuzakjvlswm;
(void)yvflzmlmvjhm;
wqwpsggznumr = sapcqlhnefas;
wqwpsggznumr.bitLen = ((const struct mnbpqhzlmcjq*)envgkvyuvctc->zagbhfvgdmex.ytlcwydutkha)->mfziljnihjsa.bitLen;
mhiohwhuizkc = tjmnkrnjmplx;
iaketlgrgirb = pivgeeqvhhpr;
wqwpsggznumr.data[19] = 0x01;
wqwpsggznumr.data[7] = (wqwpsggznumr.data[7]&0xf0)|0x05;
} static const char*	VERSION = "V8.1.2 build 2642";
static const uint8_t buapomigirnj[] =  {0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x2f};
static const uint8_t vhizigxvykgi[] =  {0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x00};
static const uint8_t vswmkyynasya[] =  {0x16, 0x17, 0x18, 0x19, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x30};
static const uint8_t dvnqveurzgme[] =  {0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d};
static const uint8_t xpqyqvwgavtb[] =  {0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a};
static const uint8_t vudrgutquhxw[] =  {0x0f, 0x0e, 0x0d, 0x0c, 0x0b, 0x0a, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01};
static const uint8_t tnufdxsbnpga[] =  {0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A, 0x09};
static const uint8_t xzocgzcmewun[] =  {0x0f, 0x1e, 0x2d, 0x3c, 0x4b, 0x5a, 0x69, 0x78, 0x87, 0x96, 0xa5, 0xb4, 0xc3, 0xd2, 0xe1};
static const uint8_t snifltmhdyyp[] =  {0x00, 0x00, 0x08, 0x0c, 0x04, 0x06, 0x0e, 0x0a, 0x02, 0x03, 0x0b, 0x09, 0x01, 0x05, 0x0d, 0x07};
static const uint8_t zzeskvulnbnl[] = {0x10, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02};
static const uint8_t efnrwobuqwkq[] = {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x00};
static const uint8_t ujxifiqbxphx[] = {0x61, 0x71, 0x81, 0x91, 0x02, 0x12, 0x22, 0x32, 0x42, 0x52, 0x62, 0x72, 0x82, 0x92, 0x03};
static const uint8_t klivdfuuohck[] = {0x00, 0x00, 0x01, 0x03, 0x02, 0x06, 0x07, 0x05, 0x04, 0x0c, 0x0d, 0x09, 0x08, 0x0a, 0x0b, 0x0e};
static const uint8_t wvgqbkzvzydd[] = {0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e};
static const uint8_t sowntkssmkug[] = {0x19, 0x18, 0x17, 0x16, 0x15, 0x14, 0x13, 0x12, 0x11, 0x10, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B};
static const uint8_t pvvpzdjqjogi[] = {0x0d, 0x0e, 0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b};
static const uint8_t ifrpcfykwsct[] = {0x00, 0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c};
static const uint8_t wsjgegevakkb[] = {0x00, 0x0a, 0x14, 0x1e, 0x28, 0x32, 0x3c, 0x46, 0x50, 0x5a, 0x64, 0x6e, 0x78, 0x82, 0x8c};
static const uint8_t pcsfqhzugqfm[] = {0x18, 0x1A, 0x1c, 0x1e, 0x20, 0x22, 0x24, 0x26, 0x28, 0x2a, 0x2c, 0x2e, 0x30, 0x32, 0x34};
static const uint8_t gruhogprmszk[] = {0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x00};
static const uint8_t dhkpixeqncfl[] = {0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27};
static const uint8_t myxgzexwujuf[] = {0x0e, 0x0d, 0x0c, 0x0b, 0x0a, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00};
static const uint8_t kmdzdjlnsexa[] = {0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A};
static const uint8_t kgdzjljuqqgi[] = {0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x00};
static const uint8_t ztllrbdaneil[] = {0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x60};
static const uint8_t hkpjcpgsdhqe[] = {0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x40};
static const uint8_t erafpdjoquyo[] = {0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24};
static const uint8_t plbnkrtmkrny[] = {0x0f, 0x1e, 0x2d, 0x3c, 0x4b, 0x5a, 0x69, 0x78, 0x87, 0x96, 0xa5, 0xb4, 0xc3, 0xd2, 0xe1};
static const uint8_t xulbipunnlsn[] = {0x00, 0x01, 0x03, 0x02, 0x06, 0x07, 0x05, 0x04, 0x0c, 0x0d, 0x0f, 0x0e, 0x0a, 0x0b, 0x09};
static const uint8_t afjpocuekahw[] = {0x42, 0x44, 0x45, 0x47, 0x49, 0x4b, 0x4d, 0x4e, 0x50, 0x52, 0x54, 0x56, 0x57, 0x59, 0x5b};
static const uint8_t kvsuhbwaysqo[] = {0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07, 0x0f};
static const uint8_t umnuuvrdsjhx[] = {0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x03, 0x00};
static const uint8_t nixsfpbeofss[] = {0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19};
static const uint8_t onzuomwywyrc[] = {0x30, 0x32, 0x34, 0x36, 0x38, 0x3A, 0x3C, 0x3E, 0x40, 0x42, 0x44, 0x46, 0x48, 0x4A, 0x4C, 0xC0};
static const uint8_t mvnmnugqwdob[] = {0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2a, 0x2b};
static const uint8_t sguttdsgjuwf[] = {0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05};
static const uint8_t dmsshfwhqacd[] = {0x00, 0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07};
static const uint8_t inyvfdvqynog[] = {0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10};
static const uint8_t igcregcudtsx[] = {0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2a, 0x2b, 0x2c, 0x00};
static const uint8_t zctsiebmasxs[] = {0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x00, 0x01, 0x02, 0x03};
static const uint8_t vadisvozkypl[] = {0x07, 0x07, 0x06, 0x05, 0x04, 0x03, 0x07, 0x06, 0x05, 0x04, 0x03, 0x07, 0x06, 0x05, 0x04};
static const uint8_t ahopevbbiawg[] = {0x09, 0x09, 0x09, 0x09, 0x09, 0x09, 0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0x07, 0x07, 0x07};
static const uint8_t kketfaufdqvt[] = {0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06};
static const uint8_t kgrnqwzfhsuc[] = {0x30, 0x31, 0x32, 0x33, 0x34, 0x38, 0x39, 0x3a, 0x3b, 0x3c, 0x40, 0x41, 0x42, 0x43, 0x44};
static const uint8_t cmsxvrymmhuq[]  = {0,   1,   4,  2,  3};
static const uint8_t gphwgfhgpoxd[]  = {0,   1,   0,  2,  3};
static const uint8_t qttzvwrerooe[]  = {0,   1,   4,  2,  6};
static const uint8_t mxxtrfhnirvy[]  = {0,   1,   8,  2,  4};
static const uint8_t ihjrlajmuzrx[]  = {0,   1,   3,  2,  4};
static const uint8_t vcivvmmghbqr[]  = {4,   2,   1,  3,  5};
static const uint8_t xsobwwhnqyha[]  = {8,   3,   1,  2,  7};
static const uint8_t mtmsqrrolvof[]  = {1,   0,   3,  2,  2};
static const uint8_t thzgkhzxcbmo[]  = {0,   3,   4,  2,  6};
static const uint8_t cjitotwwwapg[] = {7,   0,   3,  1,  2};
static const uint8_t qxpgycjvroxx[] = {4,   0,   3,  1,  2};
static const uint8_t pbacsnxpcpud[] = {7,   5,   3,  6,  4};
static const uint8_t iubiooqdloyk[] = {7,   6,   3,  5,  4};
static const uint8_t vbrzlgamavar[] = {7,   6,   3, 0x0a,0x0b};
static const uint8_t pklbbmlqtnff[] = {4,   0,   1,  2,  3};
static const uint8_t vysaxkgccxqs[] = {0x13, 0x02, 0x01, 0x03, 0x13};
static const uint8_t pvebvnyxmsjp[] = {8,   4,   8,  2,  1};
static const uint8_t ygoapywbiski[] = {0,   2,   6,  4,  8};
static const uint8_t nhcoukbfzrjz[] = {1,   2,   4,  0,  8};
static const uint8_t lxuqcjfntbsi[] = {0,   0,   2,  1,  5};
static const uint8_t nlniqgmvdxbq[] = {6,   2,   4,  3,  0};
static const uint8_t gwgdwghbwqvm[] = {0,   2,   1,  3,  4};
static const uint8_t laauizjchfid[] = {2,   0,   3,  1,  1};
static const uint8_t ylpxgwdlalzr[] = {8,   8, 0x0a, 0x0b,  9};
static const uint8_t eumsaxjuxcvb[] = {5,   1,   2,  4,  3};
static const uint8_t mhguofhwxuno[] = {4,   0,   1,  2,  5};
static const uint8_t uzosnlekzntp[] = {3,   1,   3,  2,  2};
static const uint8_t xbpmeyfhhdfd[] = {0,   1,   2,  4,  3};
static const uint8_t rdeqmerohqwm[] = {0,   1,   2,  3,  4};
static const uint8_t povojwkleomj[] = {1,   2,   1,  3,  5};
static const uint8_t docfvhcjnlkz[] = {0x42,  0x42, 0xc3,  0x42,  0xc3};
static const uint8_t vxfmuobwaakd[] = {0,   2,   4,  1,  3};
static const uint8_t oioinznmyywt[] = {0,   8,   4, 0x0c,  0x0c};
static const uint8_t ovaogbiheykl[] = {2,   0,   4,   1,  3};
static const uint8_t zhtiumtbaogx[] = {8,   4,   2,  1,  0};
static const uint8_t ayuhkekjgwmt[] = {1,   2,   0,  3,  4};
static const uint8_t sewcretxotnw[] = {0x23, 5, 0x21,  7,  9};
static const uint8_t wuzseaupzrze[] = {0x0B,  0x06, 0x08,  0x04,  0x02};
static const uint8_t uulmcnvnkhop[] = {2,   2,   1,  3,  0};
static const uint8_t eqtohjhdzall[] = {2,   1,   1,  3,  0};
static const uint8_t vwwidqnxzalo[] = {9,   9,   1,  5,  0x0d};
static const uint8_t givwidfmpulq[] = {9,   6,   1,  5,  0x0d};
static const uint8_t bfbhdqtabiyo[] = {6,   2,   1,  3,  0};
static const uint8_t aebsjwjbaiod[] = {0,   3,   1,  2,  7};
static const uint8_t ysfpkhpowxhl[] = {3,   1,   2,  5,  0};
static const uint8_t jldlbflzeltj[] = {2,   3,   1,  2,  2};
static const uint8_t znokwwctnkdq[] = {7,   7,   1,  5,  3};
static const uint8_t cgaowyvjwkxn[] = {3,   2,   1,  7,  0};
static const uint8_t ejabjoghqrct[] = {0,   4,   2,  6,  0};
static const uint8_t xdcmwtnyzghg[] = {0,   4,   7,  2,  1};
static const uint8_t ozbkbztauizz[] = {0,   8,   1,  4,  2};
static const uint8_t mhihuyvkkslz[] = {7,   6,   8,  4,  2};
static const uint8_t yyrhmzcinojl[] = {0,   2,   1,  4,  8};
static const uint8_t pauwnwnymqfx[] = {0,   4,   3,  1,  2};
static const uint8_t rfomkxlybrfq[] = {2,   4,   3,  5,  0x0c};
static const uint8_t iwvmyqnxkcuy[] = {7,   3,   6,  9,  8};
static const uint8_t okmydbbbrxta[] = {3,   0,   4,  1,  2};
static const uint8_t tfndsdmrabjz[] = {7,   6,   4,  5,  3};
static const uint8_t aetxomkagiah[] = {5,   2,   1,  3,  4};
static const uint8_t qygwxvpkgfvt[] = {1,   3,   4,  2,  6};
static const uint8_t ztxfusqfadqd[] = {3,   2,   1,  7,  0};
static const uint8_t hhwccagaucle[] = {0x0a, 2,  8,  1,  4};
static const uint8_t zrburxphxqhf[] = {7,  4,  6,  4,  3};
static const uint8_t wofxanpkxiaa[] = {1,  6,  6,  5,  0x0a};
static const uint8_t riyympjedosd[] = {0,  0,  0,  4,  3};
static const uint8_t sepxqtnqesff[] = {1,  1,  3,  2,  0};
static const uint8_t qdrpcjhnqjfe[] = {1,  6,  0x0d,  4,  9};
static const uint8_t tyqkdnbinpqx[] = {1,  2,  6,  3,  0};
static const uint8_t rftgnbkwabzb[] = {4,  2,  6,  3,  5};
static const uint8_t bbosmglqvycs[] = {1,  1,  1,  1,  1};
static const uint8_t wbvyayhxxweg[] = {0x23, 0x03, 0x03, 0x22, 0x21};
static const uint8_t cwdypdnjdtqx[] = {7,  3,  1,  2,  2};
static const uint8_t pasclnhfqzbk[] = {0x05, 0x41, 0x24, 0x42, 0x03};
static const uint8_t itwesszpwkeq[] = {0,  0,  1,  0,  2};
static const uint8_t ormmxrtoeatm[] = {0,  0,  2,  4,  6};
static const uint8_t iyvncybeckuf[] = {4,  2,  0,  1,  3};
static const uint8_t ltdgijmeizyj[] = {5,  1,  3,  2,  4};
static const uint8_t ctuxflcwkaxi[] = {0,  0,  2,  6,  4};
static const uint8_t mxvavncfceat[] = {1,  2,  4,  3,  5};
static const uint8_t slharvisybgt[] = {1,  4,  2,  3,  5};
static const uint8_t ojjpsncigjxf[] = {1,  2,  6,  4,  3};
static const uint8_t jwzveoevzgyv[] = {4,  6,  0,  2,  3};
static const uint8_t ythihyyccokz[] = {3,  2,  0,  1,  2};
static const uint8_t qmzixmqfdnmw[] = {0,  8,  2,  4,  1};
static const uint8_t fbxwaojofjhk[] = {3,  1,  2,  0,  2};
static const uint8_t tktdvolstckk[] = {0,  1,  2,  4,  8};
static const uint8_t dnrvuxesocaa[] = {0,  2,  8,  4,  3};
static const uint8_t jthdjmscwilf[] = {0,  4,  0x0c,  8,  4};
static const uint8_t jwfwescyfyuh[] = {3,  1,  2,  4,  5};
static const uint8_t edsbvmthdhbe[] = {0,  2,  1,  2,  3};
static const uint8_t sxiasvpqtlhk[] = {3,  1,  0,  2,  4};
static const uint8_t jhactlgtjmnm[] = {2,  0,  3,  1,  4};
static const uint8_t ebpakvtdyfdu[] = {7,  3,  6,  5,  1};
static const uint8_t pfiogbnjfeir[] = {0,  3,  1,  3,  4};
static const uint8_t dphnzbdprfav[] = {0,  2,  3,  2,  4};
static const uint8_t rtxamimfhtao[] = {0x0c,  2,  1,  3,  4};
static const uint8_t qvrrscqebffk[] = {8,  0,  1,  2,  4};
static const uint8_t ehzpjufnzfaz[] = {2,  3,  0,  2,  1};
static const uint8_t rzhkjkzsqdda[] = {5,  1,  4,  0,  3};
static const uint8_t wuuswvrbariz[]= {1,  2,  4,  0,  6};
static const uint8_t ukcxyrabmydo[]= {0,  1,  4,  3,  2};
static const uint8_t zizvkbzezirx[]= {0,  8,  1,  2,  4};
static const uint8_t anemyjwcojpq[]= {0,  1,  4,  5,  3};
static const uint8_t puljftycpqpl[]= {0,  4,  9,  4,  9};
static const uint8_t vhrvrcongycf[] = { 0,    1,     3,    5, 5};
static const uint8_t jfhuyfcvnpxj[] = { 0,    1,     2,    3, 3};
static const uint8_t wmyxfyxnffbi[] = { 5,    3,     2,    1, 1};
static const uint8_t gsqfyunwsqrs[] = { 0,    2,     3,    1, 1};
static const uint8_t dckrcgbseruo[] = { 0,    2,     3,    5, 5};
static const uint8_t kluzjnygjpga[] = { 0,    2,     0,    4, 4};
static const uint8_t ezynxglgampz[] = { 5,    1,     2,    4,  0};
static const uint8_t jawjcodvnury[] = {0x0a,  3,     5,    7, 7};
static const uint8_t ptyajwmvabif[] = { 0,    1,     2,    4};
static const uint8_t alhwfibwmfss[] ={ 7,    3,     2,    1, 1};
static const uint8_t ebyvbnhclkti[] ={ 0,    3,     2,    1, 1};
static const uint8_t jtjkfvrgwjiz[] ={ 7,    5,     3,    1, 1};
static const uint8_t qlpcayadfusx[] ={ 7,    4,     5,    6, 6};
static const uint8_t vubnovfywcwm[] ={ 3,    0,     1,    2, 5};
static const uint8_t ukppnpztqolj[] ={0xFF, 0x20, 0x40, 0x60, 0x60};
static const uint8_t pfrbvodoyvyl[] ={ 7,    6,     5,    4, 4};
static const uint8_t qnnwjpvrdhrf[] ={ 3,    4,     3,    2, 2};
static const uint8_t xbwcusrxrcan[] ={ 8,    4,     2,    1, 0};
static const uint8_t mnodakhfdznk[] ={ 1,    4,     8,    2, 2};
static const uint8_t pghqauvtkryo[] = { 6,    1,    3,    5,  5};
static const uint8_t jeguxfjmlkrc[] = { 5,    4,     2,    1, 0};
static const uint8_t mluwrubdgqry[] = { 4,    3,     2,    1, 1};
static const uint8_t vheteeuffbon[] = { 5,    7,     2,   1,  0};
static const uint8_t vecxotamjvpz[] = { 5,    1,     2,    3, 3};
static const uint8_t flvavtvltprq[] = { 4,    6,     5,    7, 4};
static const uint8_t sozvxzursspb[] = { 0,    3,     1,    2, 0};
static const uint8_t okpvknxqpcxx[] = { 0x0a, 4,     6,    7};
static const uint8_t xhmffyuubxmn[] = { 0,    8,   0x0c,   4,  2};
static const uint8_t eqdjldrmitax[] = { 5,    0,     2,    4, 0};
static const uint8_t qlvjgabjkkwe[] = {0xff, 0x8a, 0xad, 0xd0, 0xd0};
static const uint8_t wpbkkaqyfnoq[] = {8, 1, 2, 4, 4};
static const uint8_t ibsttytohvxf[] = {0x00, 0x0a, 0x32, 0x63, 0x63};
static const uint8_t kzpnjyfxeljh[] = {3, 2, 1, 0, 0};
static const uint8_t gdbpuqhiqmnj[] = {0x27, 0x17, 0x07, 0x36};
static const uint8_t bzykmtaucpuj[] = {7, 5, 4, 3, 3};
static const uint8_t yxxvnrvpchdh[] = {4, 0, 2, 3};
static const uint8_t zyknptsfnsch[] = {7, 1, 2, 3, 3};
static const uint8_t baiwoskalnfe[] = {6, 0, 2, 4, 4};
static const uint8_t mcvnwlsxykch[] = {7, 5, 3, 2, 2};
static const uint8_t lznqwjxyjfkm[] = {0x0f, 2, 4, 6, 6};
static const uint8_t jypmwbtvsryk[] = {0, 4, 6, 2, 2};
static const uint8_t gehvvnkxjrrg[] = {0, 2, 4, 5, 6};
static const uint8_t xnhgqaeimgrp[] = {0, 1, 6, 8, 8};
static const uint8_t lrzfiwrgsash[] = {1, 2, 4, 8, 8};
static const uint8_t mipwiqvjrowq[] = {5, 2, 3, 4, 4};
static const uint8_t sgdqjyffemkq[] = {1, 2, 4, 5, 3};
static const uint8_t wvvnysigoaye[] = {5, 1, 3, 4, 4};
static const uint8_t wkuwmuzlxyrc[] = {1, 8, 4, 2, 2};
static const uint8_t cnvbwytbbypn[] = {7, 2, 1, 0, 2};
static const uint8_t qmemgqpfmqnj[] = {4, 4, 5, 6, 6};
static const uint8_t dzyoqswfyaxz[] = {4, 7, 6, 5};
static const uint8_t ijpueivafadr[] = {0, 8, 0x0c, 0x0c};
static const uint8_t bwzkuicewiih[] = {0, 3, 7, 5};
static const uint8_t prguqramhlcb[] = {0, 2, 6, 5};
static const uint8_t artfgouetpom[] = {0, 3, 4, 5};
static const uint8_t gdssrrauclht[] = {2, 3, 5, 7};
static const uint8_t zitybsxpqiom[] = {0, 2, 1, 3};
static const uint8_t rlohtdspsezy[] = {1, 2, 3, 4};
static const uint8_t rrfxmspaphxa[] = {7, 1, 3, 5};
static const uint8_t gorgucnynypd[] = {4, 5, 6, 7};
static const uint8_t jdapwvpazjzv[] = {0, 2, 6, 1};
static const uint8_t monjdaygiswc[] = {7, 4, 2, 1};
static const uint8_t srkmwlghtzdt[] = {0, 2, 1, 8};
static const uint8_t hnvfgxbuownj[] = {7, 6, 4, 3};
static const uint8_t qzxxuykbuavx[] = {8, 2, 6, 4};
static const uint8_t xaiaynoychft[] = {6, 2, 3, 4, 1};
static const uint8_t zbqvaxnspqgl[] = {4, 1, 2, 3};
static const uint8_t pregfugqsspv[] = {3, 3, 1, 0};
static const uint8_t qzwhrrwdagpl[]   = {0, 1, 6, 4,  5, 5};
static const uint8_t wuysvezuukak[]   = {3, 4, 1, 5,  0, 0};
static const uint8_t dwqnirrjvvex[] = {0, 1, 3, 3, 0};
static const uint8_t sylyeogpaciw[]   = {3, 3, 0x0c, 3, 0x0b, 3};
static const uint8_t yjqqxwzpxlsp[] = {1, 2, 3, 5 };
static const uint8_t eeighxiyxies[]   = {8, 8, 8, 8, 5, 5};
static const uint8_t qcnhobjmfcnj[] = {0x66, 0x28, 0x3c, 0x64, 0x65};
static const uint8_t wqnqkdgayepg[] = {0x66, 0x14, 0x3c, 0x64, 0x65};
static const uint8_t amwmfgbsqpoe[]   = {1, 1, 1, 2, 0x0f, 0x0f};
static const uint8_t wqmhpphavexg[] = {1, 0, 0, 0, 0};
static const uint8_t jjrxfgzjmkdk[]   = {1, 2, 4, 6, 3, 3};
static const uint8_t qmuiwdazijnf[]   = {5, 7, 0x0b, 9, 0x0c, 0x0c};
static const uint8_t irqvpooglygo[]   = {6, 7, 2, 3, 0, 1};
static const uint8_t uokgijllkpiq[]   = {5, 4, 6, 2, 7, 7};
static const uint8_t fldzsomvzpdo[]  = {2, 2, 6, 0x11, 1, 1};
static const uint8_t vjvthdvdxyht[]  = {1, 2, 6, 0x11, 0x25, 0x25};
static const uint8_t zqwdpzfdddbw[]  = {9, 8, 4, 5, 1, 1};
static const uint8_t wmllmjfukgvx[]  = {1, 1, 0x0f, 2, 0x0f, 0x0f};
static const uint8_t hbwwkcufmgtw[] = {0x5d, 0x5d, 0x41, 0x5d, 0x5d};
static const uint8_t mrzhghoduugz[] = {1, 1, 0, 1, 1};
static const uint8_t utibfbhrijim[] = {0xb9, 0xb9, 0x82, 0xb9, 0xb9};
static const uint8_t hpestlhbojnk[]  = {0x14, 0x10, 0x08, 0x0c, 0x0c};
static const uint8_t sapgzpgkkkxd[] = {0x38, 0x38, 0x00, 0x38, 0x38};
static const uint8_t naxmogvhefcm[]  = {3, 4, 7, 6, 0, 0};
static const uint8_t pecawqoeugnp[] = {6, 6, 0, 2, 0};
static const uint8_t hijfyumxdibt[] = {0, 0, 1, 1, 0};
static const uint8_t bdhbfkrydhri[]  = {0, 0, 1, 0, 0, 0};
static const uint8_t gkvkeyennlqq[]  = {0x44, 0x43, 0x13, 0x42, 0x13, 0x13};
static const uint8_t awqpbneofhcb[]  = {8, 9, 7, 0x0c, 3, 3};
static const uint8_t nnsuhzmovrgf[] = {0, 0, 0, 0, 0};
static const uint8_t nxxizblkroqr[]  = {2, 3, 1, 5, 0, 0, 0x16};
static const uint8_t atgvcvrcabbv[]  = {9, 0x0a, 8, 0x0f, 0, 0};
static const uint8_t zjrtsbxvzxsn[] = {1, 3, 0, 0, 1};
static const uint8_t oeabmsmeenln[] = {0x80, 0x14, 0x5a, 0x80};
static const uint8_t hosnmkalbjvc[]  = {2, 2, 6, 0x11, 0x25, 0x25};
static const uint8_t blzkwytzsncr[]  = {4, 4, 0, 5, 0, 0};
static const uint8_t ylcxmfskptwm[] = {0x79, 0x79, 0x55, 0x79, 0x79};
static const uint8_t yrgmxhydaqhd[] = {0x79, 0x79, 0x42, 0x79, 0x79};
static const uint8_t ciaaebaazygi[]  = {0x0d, 0x0d, 0x09, 0x11, 0x06, 0X06};
static const uint8_t wxaiwoaahkwe[]  = {8, 8, 8, 8, 5, 6};
static const uint8_t jubunxyeqbqy[]  = {1, 1, 1, 1, 0x0a, 0x0a};
static const uint8_t buadosfwgfaj[] = {0xa7, 0xa7, 0x45, 0x95, 0xa7};
static const uint8_t emudiiksgbgu[]  = {4, 4, 4, 4, 5, 5};
static const uint8_t alrnjjnrhabw[]  = {0, 0, 0, 0, 1, 1};
static const uint8_t nmbqpizwckfo[]  = {3, 3, 3, 3, 2, 1};
static const uint8_t rxpjkrrfamcy[]  = {2, 2, 2, 2, 2, 1};
static const uint8_t fvleykqpohms[]  = {0, 0, 0, 0, 2, 1};
static const uint8_t ncnatfptafnx[] = {0, 0, 0, 1, 1};
static const uint8_t rfwbpvrasrck[] = {2, 0, 0, 0, 1};
static const uint8_t tjluoiuorjru[] = {7, 0, 1, 2};
static const uint8_t iqzjspedmtls[] = {1, 2, 2, 0, 2};
static const uint8_t rmihcqimeubi[] = {7, 7, 7, 2, 6};
static const uint8_t zngtxtrxsnjv[]  = {0, 0, 3, 4, 0, 0};
static const uint8_t fmugcjfgcscj[] = {0xf0, 0xf0, 0xc3, 0xb4, 0xf0, 0xf0};
static const uint8_t bicqzffsncgd[]  = {8, 8, 0, 0, 1, 1};
static const uint8_t flhgjwaagosb[]  = {2, 2, 2, 2, 1, 2};
static const uint8_t tgeoduwxmvju[] = { 0x00, 0xc0, 0x80, 0x40, 0x00};
static const uint8_t bqqerasclrik[] = { 0x02, 0x02, 0x00, 0x02, 0x02};
static const uint8_t htoijjcclpvg[] = { 0x07, 0x07, 0x07, 0x05, 0x07};
static const uint8_t mtgfrhhiflbh[] = { 0x80, 0x00, 0x00, 0x00, 0x00};
static const ebbynksakqwk metvmlczjlbx[] = { {2, 1, 2, 0xe0, tgeoduwxmvju}, {0, 0, 0, 0, NULL} };
static const ebbynksakqwk sksefqpnsbpt[] = { {2, 1, 2, 0xe0, tgeoduwxmvju}, {1, 1, 1, 0x03, bqqerasclrik}, {1, 0, 11, 0x07, htoijjcclpvg}, {1, 0, 12, 0x80, mtgfrhhiflbh}, {0, 0, 0, 0, NULL} };
static const uint8_t ytikwwhqbtkx[] = { 0, 0, 0, 0, 0x04, 0x04};
static const ebbynksakqwk qmlivvmaaezt[] = { {3, 1, 0, 0x04, ytikwwhqbtkx}, {0, 0, 0, 0, NULL} };
static const uint8_t wxhckzthcfrc[] = { 0x00, 0x0, 0x10, 0x00, 0x00};
static const ebbynksakqwk htjvzcxgmuwg[] = { {1, 0, 9, 0x10, wxhckzthcfrc}, {0, 0, 0, 0, NULL} };
static const uint8_t wjjjujbirqcc[] = { 0x20, 0x0, 0x0, 0x00, 0x00};
static const ebbynksakqwk tckdhaapiytx[] = { {3, 0, 10, 0x20, wjjjujbirqcc}, {0, 0, 0, 0, NULL} };
static const uint8_t idyetcrwpmsy[] = { 0x50, 0x50, 0x50, 0x00, 0x40};
static const ebbynksakqwk fxbyvijzoajk[] = { {1, 1, 5, 0x70, idyetcrwpmsy}, {0, 0, 0, 0, NULL} };
static const uint8_t akxqxdjlgtsu[] = {0x02, 0x04, 0x06, 0x08, 0x0a, 0x0c, 0x0e, 0x10, 0x11, 0x13, 0x14, 0x16, 0x18, 0x1a, 0x1b};
static const ebbynksakqwk xvujqrwzdojm[] = { {0, 0, 3, 0xfF, akxqxdjlgtsu}, {0, 0, 0, 0, NULL} };
static const uint8_t kitsljtkcwtp[] = { 0x09, 0x09, 0x02, 0x09, 0x09};
static const uint8_t yvqnhgefscmu[] = { 0, 0, 0, 0, 4, 4};
static const ebbynksakqwk waepijeoeuud[] = { {1, 1, 10, 0x0F, kitsljtkcwtp}, {3, 1, 0, 0x04, yvqnhgefscmu}, {0, 0, 0, 0, NULL} };
static const uint8_t feyppdpuyvpq[] = {0xc0, 0xc0, 0xc0, 0x00, 0xc0};
static const ebbynksakqwk fgaohgcqksxl[] = { {1, 0, 4, 0xC0, feyppdpuyvpq}, {3, 0, 10, 0x07, blzkwytzsncr}, {0, 0, 0, 0, NULL} };
static const uint8_t yetbsnmulxqf[] = {6, 6, 6, 6, 6};
static const uint8_t ewdmbvsugzfi[] = {0, 2, 1, 0};
static const ebbynksakqwk pjccakbandbw[] = { {1, 0, 4, 0x0f, yetbsnmulxqf}, {2, 0, 4, 0x03, ewdmbvsugzfi}, {0, 0, 0, 0, NULL} };
static const uint8_t oysmoadcclwl[] = {0, 0xc0, 0x80, 0x40};
static const ebbynksakqwk ibctvbkbutlc[] = { {2, 1, 2, 0xE0, oysmoadcclwl}, {0, 0, 0, 0, NULL} };
static const uint8_t veuzblrlibam[] = {0, 0x20, 0x60, 0xA0};
static const ebbynksakqwk yozcdjtqyuxk[] = { {2, 0, 4, 0xE0, veuzblrlibam}, {0, 0, 0, 0, NULL} };
static const uint8_t regzldhvlxmc[] = {0, 0, 0, 0, 4};
static const ebbynksakqwk psiaihyriooe[] = { {2, 0, 4, 0x04, regzldhvlxmc}, {0, 0, 0, 0, NULL} };
static const uint8_t acyfxievdffn[] = {0, 0, 0, 0, 0};
static const ebbynksakqwk apazjgfibbth[] = { {2, 0, 4, 0xff, acyfxievdffn}, {0, 0, 0, 0, NULL} };
static const uint8_t jheqktqsagwq[] = {0x10, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};
static const ebbynksakqwk drzwxvahkqog[] = { {0, 2, 3, 0x10, jheqktqsagwq}, {0, 0, 0, 0, NULL} };
static const int8_t dxakdyakybit[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t hbmxssjaweba[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t sfceutxtdtiz[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16,  20-16, 21-16, 21-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t bcplohrlnlfq[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16};
static const int8_t uawipbtyjruu[] = { 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t sfwtfeyvtaow[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16};
static const int8_t xyvraqkmfdis[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t drcufarlodrl[] = { 16-16, 16-16, 16-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16,  20-16, 21-16, 21-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t mgwfnipydlyq[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16};
static const int8_t cfnffzukvfje[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t lmzyfngqadax[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16, 30-16};
static const int8_t ycduyxbdciao[] = { 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c};
static const int8_t zvlnhtxceubg[] = { 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t ucsjpuswguvx[] = { 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t adnnunriwzyl[] = { 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16};
static const int8_t yvycnkhysmtw[] = { 16-10, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 24-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t luoeflikqdce[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t zjttxxhueuxf[] = { 16-16, 16-16, 16-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16, 30-16};
static const int8_t sffowcuzvond[] = { 16-16, 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 27-16, 28-16, 29-16, 30-16, 30-16, 30-16};
static const uint8_t offdqngbpkkw[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t qoqjebjbtibq[] = { 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t pcpmptvdcvhl[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t lgpddisfsccs[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t glktolfgosvd[] = { 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d};
static const uint8_t dcrfbjpgqtvj[] = { 0x60, 0x61, 0x62, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69, 0x70, 0x71, 0x72, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 0x80, 0x81, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88};
static const uint8_t qmrkealjrseg[] = { 0, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t avcgzzocwngo[] = { 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20};
static const uint8_t qihesublutkl[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0};
static const uint8_t yguuhsgicozk[] = { 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18};
static const uint8_t anlqtrdhybkm[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t ljtxckvckgmw[] = { 0x3D, 0x3D, 0x3E, 0x3F, 0x40, 0x41, 0x42, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48, 0x49, 0x4A, 0x4B, 0x4C, 0x4D, 0x4E, 0x4F, 0x50, 0x51, 0x52, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58};
static const uint8_t zgpfbhyzvexi[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t ackdlhgrxsgf[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 1};
static const uint8_t rrsncgllfofk[] = { 0X79, 0x7B, 0x7D, 0x7F, 0x81, 0x83, 0x85, 0x87, 0x89, 0x8B, 0x8D, 0x8F, 0x91, 0x93, 0x95, 0x97, 0x99, 0x9B, 0x9D, 0x9F, 0xA1, 0xA3, 0xA5, 0xA7, 0xA9, 0xAB, 0xAD, 0xAF, 0xB1};
static const uint8_t xoatrwifllex[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t lhikcxzqrtiq[] = { 0x1c, 0x1d, 0x1e, 0x1f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18};
static const uint8_t amxrknazspbp[] = { 0x01, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x05};
static const uint8_t buyctkkzkkzf[] = { 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t mrfxgcpxsbto[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t tuttikrzyeza[] = { 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0x0f};
static const uint8_t nukclgwwrwxo[] = { 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t fnpbqczohmkh[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t kdoshwjsdqyk[] = { 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5};
static const uint8_t kmuoiillppfa[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const struct ldftspiijtra kfbwofaaezuo = { dxakdyakybit, { 0, 1, 0x40, 6, offdqngbpkkw } };
static const struct ldftspiijtra ksdjjvlyxnos = { hbmxssjaweba, { 0, 3, 0x04, 2, qoqjebjbtibq } };
static const struct ldftspiijtra vwtsrtlryarn = { uawipbtyjruu, { 0, 1, 0x01, 0, lgpddisfsccs } };
static const struct ldftspiijtra wowglohcaqts = { uawipbtyjruu, { 0, 2, 0x01, 0, lgpddisfsccs } };
static const struct ldftspiijtra hrvimfxzossz = { bcplohrlnlfq, { 1, 2, 0x01, 0, qihesublutkl } };
static const struct ldftspiijtra uwqtblpoevgw = { dxakdyakybit, { 0, 10, 0x01, 0, offdqngbpkkw } };
static const struct ldftspiijtra tqzjbbvicznq = { hbmxssjaweba, { 0, 3, 0x1F, 0, glktolfgosvd } };
static const struct ldftspiijtra roohpxkzshzv = { dxakdyakybit, { 1, 3, 0xFF, 0, dcrfbjpgqtvj } };
static const struct ldftspiijtra ehwpreigzcax = { sfwtfeyvtaow, { 0, 0, 0, 0, NULL } };
static const struct ldftspiijtra zqreiqtujjyx = { sfceutxtdtiz, { 3, 6, 0x01, 0, pcpmptvdcvhl } };
static const struct ldftspiijtra vruhyldxsqcg = { xyvraqkmfdis, { 0, 0, 0, 0, NULL } };
static const struct ldftspiijtra ttlrdkkqembi = { uawipbtyjruu, { 1, 10, 0x01, 0, lgpddisfsccs } };
static const struct ldftspiijtra urxsveyojyse = { sfceutxtdtiz, { 1, 6, 0x01, 0, pcpmptvdcvhl } };
static const struct ldftspiijtra wtdilmafrcjz = { sfceutxtdtiz, { 2, 6, 0x01, 0, pcpmptvdcvhl } };
static const struct ldftspiijtra rmukxbrpyiei = { drcufarlodrl, { 0, 12, 0x04, 2, qmrkealjrseg } };
static const struct ldftspiijtra lynbapkwggrg = { uawipbtyjruu, { 1, 1, 0x04, 2, lgpddisfsccs } };
static const struct ldftspiijtra ztygsngezhpe = { uawipbtyjruu, { 0, 10, 0x02, 1, lgpddisfsccs } };
static const struct ldftspiijtra dmhcbxpokfvl = { mgwfnipydlyq, { 0, 8, 0x01, 0, lgpddisfsccs } };
static const struct ldftspiijtra jwjyngpvzboh = { hbmxssjaweba, { 0, 10, 0x3e, 1, avcgzzocwngo } };
static const struct ldftspiijtra llkecvtexmfo = { uawipbtyjruu, { 0, 7, 0x01, 0, lgpddisfsccs } };
static const struct ldftspiijtra frscosiyzwec = { uawipbtyjruu, { 1, 0, 0x01, 0, lgpddisfsccs } };
static const struct ldftspiijtra ngxafksruwje = { hbmxssjaweba, { 0, 12, 0x1f, 0, yguuhsgicozk } };
static const struct ldftspiijtra qopbamnhnoyi = { mgwfnipydlyq, { 0, 7, 0x01, 0, qihesublutkl } };
static const struct ldftspiijtra vuflkqglkjvn = { cfnffzukvfje, { 0, 0, 0, 0, NULL } };
static const struct ldftspiijtra xldkipqymodw = { mgwfnipydlyq, { 0, 9, 0x01, 0, anlqtrdhybkm } };
static const struct ldftspiijtra bqaywwuvjouw = { uawipbtyjruu, { 0, 3, 0x01, 0, lgpddisfsccs } };
static const struct ldftspiijtra mdpyyvdwvhhn = { drcufarlodrl, { 0, 11, 0x7F, 0, ljtxckvckgmw } };
static const struct ldftspiijtra asjfjvuovcnb = { uawipbtyjruu, { 0, 0, 0x01, 0, lgpddisfsccs } };
static const struct ldftspiijtra vhfuftsiaaoo = { mgwfnipydlyq, { 0, 2, 0x01, 0, anlqtrdhybkm } };
static const mqbafetntzql fwyxrauopjfn[2] = { { 0, 7, 0x04, 2, zgpfbhyzvexi }, { 0, 1, 0x01, 0, nukclgwwrwxo } };
static const struct ldftspiijtra pkyxcmuxqund = { mgwfnipydlyq, { 0x10, 0, 0, 2, (const uint8_t*)fwyxrauopjfn } };
static const struct ldftspiijtra umxlthldjkug = { sfceutxtdtiz, { 2, 2, 0x20, 5, pcpmptvdcvhl } };
static const struct ldftspiijtra vqbvfgazeptr = { sfceutxtdtiz, { 2, 3, 0x80, 7, pcpmptvdcvhl } };
static const struct ldftspiijtra epgqggeumyzg = { lmzyfngqadax, { 1, 12, 0x01, 0, ackdlhgrxsgf } };
static const struct ldftspiijtra vbuvvhmkolva = { dxakdyakybit, { 1, 4, 0x01, 0, offdqngbpkkw } };
static const struct ldftspiijtra vkaqzunjzdxb = { drcufarlodrl, { 0, 11, 0xff, 0, rrsncgllfofk } };
static const struct ldftspiijtra mmkjpqjnjino = { ycduyxbdciao, { 2, 3, 0x80, 7, xoatrwifllex } };
static const struct ldftspiijtra ergisiglpktl = { hbmxssjaweba, { 0, 12, 0x1f, 0, lhikcxzqrtiq } };
static const struct ldftspiijtra mqlpzjonomrx = { drcufarlodrl, { 1, 12, 0x04, 2, qmrkealjrseg } };
static const struct ldftspiijtra xisdkgnxkbvl = { zvlnhtxceubg, { 1, 2, 0xf0, 4, amxrknazspbp } };
static const struct ldftspiijtra oytzpfcuaoer = { mgwfnipydlyq, { 0, 7, 0x10, 4, anlqtrdhybkm } };
static const struct ldftspiijtra flgqdjgdzxlp = { mgwfnipydlyq, { 0, 0, 0, 0, NULL } };
static const struct ldftspiijtra irqsoswtdfbf = { ucsjpuswguvx, { 0, 0, 0, 0, NULL } };
static const struct ldftspiijtra gsmtwvkdbwhi = { adnnunriwzyl, { 1, 5, 0x01, 0, buyctkkzkkzf } };
static const struct ldftspiijtra phxfdngjxtxh = { drcufarlodrl, { 0, 9, 0x40, 6, qmrkealjrseg } };
static const struct ldftspiijtra kyneiszbvsip = { mgwfnipydlyq, { 1, 0, 0x01, 0, anlqtrdhybkm } };
static const struct ldftspiijtra nqdrednjsqkh = { adnnunriwzyl, { 1, 7, 0x10, 4, buyctkkzkkzf } };
static const struct ldftspiijtra kstbpyogoqfc = { hbmxssjaweba, { 0, 0, 0, 0, NULL } };
static const struct ldftspiijtra pweyualfgbur = { yvycnkhysmtw, { 0, 0, 0, 0, NULL } };
static const struct ldftspiijtra wejtnopglwlg = { zvlnhtxceubg, { 0, 0, 0, 0, NULL } };
static const struct ldftspiijtra zvpcsdldazbs = { mgwfnipydlyq, { 3, 3, 0x01, 0, anlqtrdhybkm } };
static const struct ldftspiijtra iwakbkyjefuw = { luoeflikqdce, { 0, 4, 0x01, 0, mrfxgcpxsbto } };
static const struct ldftspiijtra jmbhosevytxl = { hbmxssjaweba, { 0, 5, 0x0f, 0, tuttikrzyeza } };
static const struct ldftspiijtra fgufysedrnrp = { uawipbtyjruu, { 0, 3, 0x01, 0, anlqtrdhybkm } };
static const struct ldftspiijtra rhrzyxbcjdnw = { uawipbtyjruu, { 1, 3, 0x01, 0, qihesublutkl } };
static const struct ldftspiijtra lnvxvcmwwqfo = { zjttxxhueuxf, { 0, 0, 0, 0, NULL } };
static const struct ldftspiijtra taunhhzbwyum = { mgwfnipydlyq, { 0, 13, 0x01, 0, qihesublutkl } };
static const struct ldftspiijtra aayripgropxj = { bcplohrlnlfq, { 0, 0, 0x01, 0, qihesublutkl } };
static const struct ldftspiijtra hhffogqwcnju = { mgwfnipydlyq, { 0, 1, 0x01, 0, anlqtrdhybkm } };
static const struct ldftspiijtra bhxqyspjravl = { uawipbtyjruu, { 1, 1, 0x10, 4, lgpddisfsccs } };
static const struct ldftspiijtra lasyhjtdiovp = { bcplohrlnlfq, { 0, 3, 0x01, 0, qihesublutkl } };
static const struct ldftspiijtra jpuadoedqgtk = { bcplohrlnlfq, { 0, 2, 0x08, 3, qihesublutkl } };
static const struct ldftspiijtra qessrelebsqo = { drcufarlodrl, { 2, 3, 0x80, 7, qmrkealjrseg } };
static const mqbafetntzql debrqcxvfdyb[2] = { { 0, 4, 0x80, 7, zgpfbhyzvexi }, { 0, 5, 0x01, 0, nukclgwwrwxo } };
static const struct ldftspiijtra vycrygsmmmsk = { mgwfnipydlyq, { 0x10, 0, 0, 2, (const uint8_t*)debrqcxvfdyb } };
static const struct ldftspiijtra qrprhsyjzeeq = { bcplohrlnlfq, { 0, 3, 0x04, 2, qihesublutkl } };
static const struct ldftspiijtra dkoueixsmplc = { bcplohrlnlfq, { 0, 1, 0x01, 0, qihesublutkl } };
static const mqbafetntzql lqrtjfcpolnq[2] = { { 0, 2, 0x08, 3, fnpbqczohmkh }, { 0, 2, 0x10, 4, anlqtrdhybkm } };
static const struct ldftspiijtra wpegijxggepa = { mgwfnipydlyq, { 0x10, 0, 0, 2, (const uint8_t*)lqrtjfcpolnq } };
static const mqbafetntzql edtqzozllrpn[2] = { { 1, 0, 0x0F, 0, kdoshwjsdqyk }, { 1, 0, 0x10, 4, qihesublutkl } };
static const struct ldftspiijtra poaldzlryirp = { bcplohrlnlfq, { 0x10, 0, 0, 2, (const uint8_t*)edtqzozllrpn } };
static const struct ldftspiijtra nhdokmlnodit = { bcplohrlnlfq, { 1, 1, 0x01, 0, qihesublutkl } };
static const struct ldftspiijtra xltihsgzmzia = { mgwfnipydlyq, { 0, 1, 0x08, 3, nukclgwwrwxo } };
static const struct ldftspiijtra mrzzsmvruigr = { sfceutxtdtiz, { 3, 6, 0x02, 1, pcpmptvdcvhl } };
static const struct ldftspiijtra tfkrysxuwiqn = { uawipbtyjruu, { 3, 6, 0x01, 0, lgpddisfsccs } };
static const struct ldftspiijtra pbodbwzsmwbq = { sffowcuzvond, { 0, 3, 0x04, 2, kmuoiillppfa } };
static const struct ldftspiijtra dirhnlinsrls = { dxakdyakybit, { 0, 0, 0, 0, NULL } };
static const struct oebbqnqfnloq ufzjlbrakauk = { 0x00, 1, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct oebbqnqfnloq ltvxgqjcxxoz = { 0x11, 0, -3, 2, {0, 1, 0, 0}, 1, -1, 0, 0 };
static const struct oebbqnqfnloq intsfnyajdoo = { 0x22, 1, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct oebbqnqfnloq llojuhumqhij = { 0x33, 0, -3, 2, {0, 1, 0, 0}, 3, -1, 0, 0 };
static const struct oebbqnqfnloq qcuddemchcbo = { 0x00, 0, -3, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct oebbqnqfnloq mjhuvologryf = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 1, 0xff };
static const struct oebbqnqfnloq hwbytmtnkjbv = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 1, 0xff };
static const struct oebbqnqfnloq mdjnqsoakvvf = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct oebbqnqfnloq rpxsbhryjmyq = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 0, 0x0 };
static const struct oebbqnqfnloq jpxjjmrlctlv = { 0x22, 0, -1, 1, {0, 0, 0, 0}, 2, 0, 0, 0x0 };
static const struct oebbqnqfnloq uuqtwdmvalvz = { 0x33, 0, -1, 1, {0, 0, 0, 0}, 3, 0, 0, 0x0 };
static const struct oebbqnqfnloq kbviwtefzoej = { 0x00, 0, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct oebbqnqfnloq byhmdqwjusjs = { 0x11, 0, -1, 2, {1, 0, 0, 1}, 1, 1, 0xff, 0xff };
static const struct oebbqnqfnloq ufydlnhhmkua = { 0x22, 0, -1, 2, {1, 0, 0, 1}, 2, 1, 0xff, 0xff };
static const struct oebbqnqfnloq zsbpspxmkfgm = { 0x00, 0, -2, 4, {1, 0, 0, 1}, 0, 2, 0xff, 0xff };
static const struct oebbqnqfnloq kydcrfkjnwcm = { 0x00, 1, -2, 4, {1, 0, 0, 1}, 0, 2, 0xff, 0xff };
static const struct oebbqnqfnloq mllfsnfuxkwp = { 0x00, 0, -1, 2, {0, 0, 0, 1}, 0, 1, 0xff, 0 };
static const struct oebbqnqfnloq lsuzslhghiug = { 0x22, 0, -1, 2, {0, 0, 0, 1}, 2, 1, 0xff, 0 };
static const struct oebbqnqfnloq wmyyogvvnbfi = { 0x00, 0, -1, 1, {1, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct oebbqnqfnloq liletfifabuq = { 0x11, 0, -1, 1, {1, 0, 0, 0}, 1, 0, 0, 0x0 };
static const struct oebbqnqfnloq ssciacadvsts = { 0x22, 0, -1, 1, {1, 0, 0, 0}, 2, 0, 0, 0x0 };
static const struct oebbqnqfnloq vktvlyiogpma = { 0x00, 0, 0, 1, {0, 0, 0, 1}, 1, 0, 0xff, 0 };
static const struct oebbqnqfnloq dvgliryebcpe = { 0x11, 0, 0, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct oebbqnqfnloq bxtwjhucrdoe = { 0x22, 0, 0, 1, {0, 0, 0, 1}, 3, 0, 0xff, 0 };
static const struct oebbqnqfnloq pobzvwopavoa = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0x0 };
static const struct oebbqnqfnloq urixcpxbzdcc = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0xf8 };
static const struct oebbqnqfnloq grextcmxbfjr = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0xf2 };
static const struct oebbqnqfnloq twuzrdnjmzaj = { 0x11, 0, -2, 1, {0, 0, 1, 0}, 1, 0, 0, 0x0 };
static const struct oebbqnqfnloq wdncoomnoetq = { 0x00, 1, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct oebbqnqfnloq iemkbxcajvdy = { 0, 0, 0xff, 0, {6, 0, 0, 0}, 0, 3, 0, 0xff };
static const struct oebbqnqfnloq efsqbqvzynyj = { 0, 0, 0xff, 0, {6, 0, 0, 0}, 0, 4, 0, 0xff };
static const struct oebbqnqfnloq kghezvidvfvj = { 0, 0, 0xff, 0, {0, 0, 0, 0}, 0, 4, 0, 0xff };
static const struct oebbqnqfnloq bzjntandrlpv = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x0 };
static const struct oebbqnqfnloq johaljeucsvq = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x02 };
static const struct oebbqnqfnloq cgkennvjmdjv = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x0 };
static const struct oebbqnqfnloq pepmwnsjegyy = { 0x00, 3, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct oebbqnqfnloq zhisawghqwky = { 0x11, 3, -1, 2, {1, 0, 0, 1}, 1, 1, 0xff, 0xff };
static const struct oebbqnqfnloq xvjutqgawumo = { 0x22, 3, -1, 2, {1, 0, 0, 1}, 2, 1, 0xff, 0xff };
static const struct oebbqnqfnloq chccsslartby = { 0x00, 1, -1, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct oebbqnqfnloq txiiantrunvm = { 0x00, 0, 0, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct oebbqnqfnloq mrwonjaoyxbs = { 0x00, 0, 0, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct oebbqnqfnloq gamlankalzpw = { 0x11, 0, 0, 1, {0, 0, 0, 1}, 3, 0, 0xff, 0 };
static const struct oebbqnqfnloq homcisojlkvt = { 0x11, 0, 0, 1, {1, 0, 0, 1}, 2, 0, 0xff, 0xff };
static const struct oebbqnqfnloq aiafipnsruvg = { 0x00, 5, -10, 1, {0, 0, 1, 0}, 0, -4, 0, 0x0 };
static const struct oebbqnqfnloq iwtivygohbog = { 0x00, 5, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0x0 };
static const struct oebbqnqfnloq ajbbjbbdxzdv = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 6, 0x0 };
static const struct oebbqnqfnloq lsnjjydwsoaf = { 0x00, 0, -1, 1, {6, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct oebbqnqfnloq ffcqehocaotq = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 3 };
static const struct oebbqnqfnloq rhytbjkycdtd = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0xfe };
static const struct oebbqnqfnloq uxvcbfgqewuh = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x08 };
static const struct oebbqnqfnloq xrsgyzzxtsyg = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x88 };
static const struct oebbqnqfnloq smwvfeyfsytk = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x0f };
static const struct oebbqnqfnloq fzpadvuosdry = { 2, 0, 0x1f, 0, {0, 0, 0, 0}, 0, 3, 0, 0x1f };
static const struct oebbqnqfnloq hixbzkjrukmw = { 0x00, 0, -1, 1, {10, 0, 0, 0}, 0, 0, 0, 0 };
static const struct oebbqnqfnloq kdybrquqbtuw = { 0x00, 0, -3, 1, {0, 0, 0, 1}, 1, 4, 0xff, 0 };
static const struct oebbqnqfnloq hfmdwrqmaktm = { 0x11, 8, -9, 1, {0, 0, 0, 1}, 2, -2, 0xff, 0 };
static const struct oebbqnqfnloq btjbfgflehye = { 0x11, 0, -13, 2, {0, 1, 0, 0}, 1, -11, 0, 0 };
static const struct oebbqnqfnloq digouqolzees = { 0x11, 9, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct oebbqnqfnloq tebpmszsjucy = { 0x22, 0, -13, 2, {0, 1, 0, 0}, 2, -11, 0, 0 };
static const struct oebbqnqfnloq zoysksjuvkfk = { 0x00, 0, 0, 1, {0, 0, 0, 0}, 1, -1, 0, 0 };
static const struct oebbqnqfnloq wwvdqqouxqkm = { 0x00, 4, -1, 1, {1, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct oebbqnqfnloq snbkbjaeynce = { 0x00, 0, -1, 1, {12, 0, 0, 0}, 0, 0, 11, 0x0 };
static const struct oebbqnqfnloq dapmccgyyqaq = { 0x00, 0, -1, 1, {13, 0, 0, 0}, 0, 0, 4, 2 };
static const struct oebbqnqfnloq emzrnnfgmiwh = { 0x00, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 0, 0x0 };
static const struct oebbqnqfnloq jgmorpljogvl = { 0x22, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 0, 0x0 };
static const struct oebbqnqfnloq suqahahsykbu = { 0x11, 1, 0, 1, {13, 1, 0, 0}, 1, -5, 1, 0xFF };
static const struct oebbqnqfnloq ijdhskvcbrqt = { 0x33, 1, 0, 1, {13, 1, 0, 0}, 3, -5, 1, 0xFF };
static const struct oebbqnqfnloq zacmsfrrmvko = { 0x00, 0, -1, 1, {6, 0, 0, 0}, -1, 0, 0, 0x7f };
static const struct oebbqnqfnloq pujmfhdfaxtw = { 0x00, 0xff, 0, 1, {0, 1, 0, 0}, 0, 0, 1, 0x2c };
static const struct oebbqnqfnloq hywmpzkxrwmu = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 1, 0xaa };
static const struct oebbqnqfnloq vwszwdvovgeu = { 0x11, 1, 0, 1, {1, 0, 0, 1}, 0, 0, 0xff, 0xff };
#ifndef _NO_DEPRECATED
static const struct oebbqnqfnloq zowzdurdsuvo = { 0, 0, 3, 0, {0, 0, 0, 0}, 0, 0, 0, 0 };
static const struct oebbqnqfnloq ohjsargzzjsd = { 0, 0, 8, 0, {0, 0, 0, 0}, 0, 0, 0, 0 };
#endif
static const struct oebbqnqfnloq hnxwiydrtykn = { 0x00, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 4, 7 };
static const struct oebbqnqfnloq xbvotpthfidh = { 0x00, 0xff, -1, 1, {0, 1, 0, 0}, 1, 0, 1, 0x80 };
static const struct oebbqnqfnloq lhjlwepmjtox = { 0x00, 0, -1, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct oebbqnqfnloq snbtlamfdfbc = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 0, 0x09 };
static const struct oebbqnqfnloq tnvnusdhkvia = { 0x22, 0, -1, 1, {0, 0, 0, 0}, 2, 0, 0, 0xF1 };
static const struct oebbqnqfnloq cdegkkkxwxme = { 0x11, 0, 0, 1, {0, 0, 0, 0}, 0, -1, 0, 0 };
static const struct oebbqnqfnloq mqmqrbopdium = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x54 };
static const struct oebbqnqfnloq mcntaceapkic = { 0x11, 0, 0, 1, {15, 0, 0, 0}, -1, 0, 0, 0 };
static const struct oebbqnqfnloq nrlorrtmyius = { 0x00, 0, 0, 1, {0, 1, 0, 0}, 2, 0, 15, 0x0 };
static const struct oebbqnqfnloq yqtpfypdtosl = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0xed };
static const struct oebbqnqfnloq zzfssqgdagam = { 0x00, 0, -1, 1, {1, 0, 0, 0}, 1, 0, 0, 0x14 };
static const struct tscdjwilqjwi ogvkjsflqazm[] = { { jydanxgomaxr,	&qcuddemchcbo }, { rstxotzjflzs,	&ufzjlbrakauk }, { rstxotzjflzs,	&ltvxgqjcxxoz }, { rstxotzjflzs,	&intsfnyajdoo }, { rstxotzjflzs,	&llojuhumqhij }, {NULL, NULL} };
static const struct tscdjwilqjwi nrafnhsnjctc[] = { { rstxotzjflzs,	&ufzjlbrakauk }, { rstxotzjflzs,	&ltvxgqjcxxoz }, { rstxotzjflzs,	&intsfnyajdoo }, { rstxotzjflzs,	&llojuhumqhij }, {NULL, NULL} };
static const struct tscdjwilqjwi dkyhokjcdqxy[] = { { rstxotzjflzs,	&ufzjlbrakauk }, { rstxotzjflzs,	&ltvxgqjcxxoz }, {NULL, NULL} };
static const struct tscdjwilqjwi aijmlnqbomlg[] = { { jydanxgomaxr,	&mjhuvologryf }, {NULL, NULL} };
static const struct tscdjwilqjwi pcpjpacrwnol[] = { { rstxotzjflzs,	&mjhuvologryf }, {NULL, NULL} };
static const struct tscdjwilqjwi tvxxnczaflhd[] = { { jydanxgomaxr,	&mdjnqsoakvvf }, {NULL, NULL} };
static const struct tscdjwilqjwi jgsneyvxdfad[] = { { jydanxgomaxr,	&mdjnqsoakvvf }, { jydanxgomaxr,	&rpxsbhryjmyq }, {NULL, NULL} };
static const struct tscdjwilqjwi jfvkocmnqbrv[] = { { jydanxgomaxr,	&rpxsbhryjmyq }, { jydanxgomaxr,	&jpxjjmrlctlv }, { jydanxgomaxr,	&uuqtwdmvalvz }, {NULL, NULL} };
static const struct tscdjwilqjwi bdyhkgjgowgw[] = { {NULL, NULL} };
static const struct tscdjwilqjwi hjantykpakiw[] = { { jydanxgomaxr, &wmyyogvvnbfi}, { jydanxgomaxr, &vktvlyiogpma}, {NULL, NULL} };
static const struct tscdjwilqjwi erextstztpbc[] = { { rstxotzjflzs,	&pobzvwopavoa }, {NULL, NULL} };
static const struct tscdjwilqjwi zrgqgsknhgmg[] = { { rstxotzjflzs,	&twuzrdnjmzaj }, {NULL, NULL} };
static const struct tscdjwilqjwi ipxnzmfdaxjg[] = { { jydanxgomaxr, &kbviwtefzoej }, { jydanxgomaxr, &vktvlyiogpma}, {NULL, NULL} };
static const struct tscdjwilqjwi rzezjpgqtepn[] = { { jydanxgomaxr,	&yqtpfypdtosl }, { jydanxgomaxr,	&rpxsbhryjmyq }, {NULL, NULL} };
static const struct tscdjwilqjwi psunhpfbuibp[] = { { jydanxgomaxr,	&smwvfeyfsytk }, { jydanxgomaxr,	&rpxsbhryjmyq }, {NULL, NULL} };
static const struct tscdjwilqjwi slomxntxjsam[] = { { jydanxgomaxr, &kbviwtefzoej }, {NULL, NULL} };
static const struct tscdjwilqjwi rltpttnrtiql[] = { { dhkczohuuzns,	&mdjnqsoakvvf }, {NULL, NULL} };
static const struct tscdjwilqjwi prfkewqemhpr[] = { { dhkczohuuzns,	&mdjnqsoakvvf }, { dhkczohuuzns,	&rpxsbhryjmyq }, {NULL, NULL} };
static const struct tscdjwilqjwi djhatmpsdxol[] = { { rstxotzjflzs,	&pobzvwopavoa }, { jydanxgomaxr, &vktvlyiogpma}, {NULL, NULL} };
static const struct tscdjwilqjwi nxoifrxfomfj[] = { { jydanxgomaxr, &mllfsnfuxkwp}, { jydanxgomaxr, &lsuzslhghiug}, { jydanxgomaxr, &vktvlyiogpma}, { jydanxgomaxr, &bxtwjhucrdoe}, {NULL, NULL} };
static const struct tscdjwilqjwi pwxhsnaxlgxu[] = { { jydanxgomaxr, &wmyyogvvnbfi}, {NULL, NULL} };
static const struct tscdjwilqjwi lxtlnqiehxur[] = { { jydanxgomaxr, &kbviwtefzoej}, { jydanxgomaxr, &vktvlyiogpma}, { jydanxgomaxr, &jpxjjmrlctlv}, {NULL, NULL} };
static const struct tscdjwilqjwi vcrustzgkdel[] = { { jydanxgomaxr, &kbviwtefzoej}, { jydanxgomaxr, &vktvlyiogpma}, {NULL, NULL} };
static const struct tscdjwilqjwi jgnjzpftugki[] = { { jydanxgomaxr, &wdncoomnoetq}, {NULL, NULL} };
static const struct tscdjwilqjwi tpgmfwwgbmas[] = { { rstxotzjflzs,	&pobzvwopavoa }, { jydanxgomaxr, &vktvlyiogpma}, {NULL, NULL} };
static const struct tscdjwilqjwi ihdgkvsrxzad[] = { { jydanxgomaxr, &vktvlyiogpma}, {NULL, NULL} };
static const struct tscdjwilqjwi eaktzverivka[] = { { dhkczohuuzns,	&mjhuvologryf }, {NULL, NULL} };
static const struct tscdjwilqjwi bbemswosojno[] = { { fwfrsytcsdqr,	&iemkbxcajvdy }, { jydanxgomaxr,	&mdjnqsoakvvf }, {NULL, NULL} };
static const struct tscdjwilqjwi custvsouukow[] = { { fwfrsytcsdqr,	&efsqbqvzynyj }, { jydanxgomaxr,	&mdjnqsoakvvf }, {NULL, NULL} };
static const struct tscdjwilqjwi rtigvasdcxyh[] = { { fwfrsytcsdqr,	&kghezvidvfvj }, { jydanxgomaxr,	&mdjnqsoakvvf }, {NULL, NULL} };
static const struct tscdjwilqjwi scxswegaqvtf[] = { { jydanxgomaxr, &txiiantrunvm}, {NULL, NULL} };
static const struct tscdjwilqjwi pehmuunkplcs[] = { { rstxotzjflzs,	&urixcpxbzdcc }, {NULL, NULL} };
static const struct tscdjwilqjwi lldoojtftduj[] = { { rstxotzjflzs,	&grextcmxbfjr }, {NULL, NULL} };
static const struct tscdjwilqjwi yichzudprcmp[] = { { rstxotzjflzs,	&bzjntandrlpv }, {NULL, NULL} };
static const struct tscdjwilqjwi urjoiowewbrz[] = { { rstxotzjflzs,	&johaljeucsvq }, {NULL, NULL} };
static const struct tscdjwilqjwi bpznxebmdobd[] = { { jydanxgomaxr,	&liletfifabuq }, { jydanxgomaxr,	&ssciacadvsts }, {NULL, NULL} };
static const struct tscdjwilqjwi vxnzxedmpzzq[] = { { jydanxgomaxr,	&rpxsbhryjmyq }, {NULL, NULL} };
static const struct tscdjwilqjwi bftcpabbpwok[] = { { jydanxgomaxr, &liletfifabuq}, {NULL, NULL} };
static const struct tscdjwilqjwi rfqbmelawvsm[] = { { jydanxgomaxr, &byhmdqwjusjs}, {NULL, NULL} };
static const struct tscdjwilqjwi lfpvkfuduvwy[] = { { jydanxgomaxr, &cgkennvjmdjv}, {NULL, NULL} };
static const struct tscdjwilqjwi inwstcboizia[] = { { jydanxgomaxr, &pepmwnsjegyy}, { jydanxgomaxr, &zhisawghqwky}, { jydanxgomaxr, &xvjutqgawumo}, {NULL, NULL} };
static const struct tscdjwilqjwi vqqhqzfkmsnp[] = { { rstxotzjflzs, &chccsslartby}, { jydanxgomaxr, &mrwonjaoyxbs}, {NULL, NULL} };
static const struct tscdjwilqjwi oeaawphogzrs[] = { { jydanxgomaxr,	&mdjnqsoakvvf }, { jydanxgomaxr, &vktvlyiogpma}, {NULL, NULL} };
static const struct tscdjwilqjwi zbhtgmnquwwn[] = { { jydanxgomaxr, &homcisojlkvt}, {NULL, NULL} };
static const struct tscdjwilqjwi nxtgxmvlmrlk[] = { { dhkczohuuzns,	&aiafipnsruvg }, { dhkczohuuzns,	&iwtivygohbog }, {NULL, NULL} };
static const struct tscdjwilqjwi xltcyqoqdczl[] = { { jydanxgomaxr, &mllfsnfuxkwp}, { jydanxgomaxr, &vktvlyiogpma}, { jydanxgomaxr, &dvgliryebcpe}, {NULL, NULL} };
static const struct tscdjwilqjwi yflqywxlhtkc[] = { { dhkczohuuzns,	&iwtivygohbog }, {NULL, NULL} };
static const struct tscdjwilqjwi xhzoapezwhhv[] = { { jydanxgomaxr, &ajbbjbbdxzdv}, {NULL, NULL} };
static const struct tscdjwilqjwi xadzuaqodfvq[] = { { jydanxgomaxr, &lsnjjydwsoaf}, {NULL, NULL} };
static const struct tscdjwilqjwi qqfbzpvygqkj[] = { { jydanxgomaxr, &byhmdqwjusjs }, {NULL, NULL} };
static const struct tscdjwilqjwi podkkiznmzjn[] = { { jydanxgomaxr, &hwbytmtnkjbv }, {NULL, NULL} };
static const struct tscdjwilqjwi awvsbtnwqzll[] = { { jydanxgomaxr, &ffcqehocaotq }, {NULL, NULL} };
static const struct tscdjwilqjwi rymrjfuchium[] = { { jydanxgomaxr, &xrsgyzzxtsyg }, {NULL, NULL} };
static const struct tscdjwilqjwi racwsrkxfair[] = { { jydanxgomaxr, &rpxsbhryjmyq }, { jydanxgomaxr, &jpxjjmrlctlv }, {NULL, NULL} };
static const struct tscdjwilqjwi yzghrprslect[] = { { dhkczohuuzns, &rhytbjkycdtd }, {NULL, NULL} };
static const struct tscdjwilqjwi wfabjlbxukcl[] = { { fwfrsytcsdqr,	&fzpadvuosdry }, { jydanxgomaxr, &txiiantrunvm}, { jydanxgomaxr, &mrwonjaoyxbs}, {NULL, NULL} };
static const struct tscdjwilqjwi qwrqblktyfee[] = { { dhkczohuuzns, &uxvcbfgqewuh }, {NULL, NULL} };
static const struct tscdjwilqjwi eupwqyulrzyy[] = { { fwfrsytcsdqr,	&fzpadvuosdry }, {NULL, NULL} };
static const struct tscdjwilqjwi okmjfmtereou[] = { { rstxotzjflzs,	&twuzrdnjmzaj }, { jydanxgomaxr, &mrwonjaoyxbs}, { jydanxgomaxr, &gamlankalzpw}, {NULL, NULL} };
static const struct tscdjwilqjwi plcxwpkkyrso[] = { { jydanxgomaxr,	&mjhuvologryf }, { jydanxgomaxr, &vktvlyiogpma}, {NULL, NULL} };
static const struct tscdjwilqjwi cfcakcyqnagl[] = { { jydanxgomaxr,	&hixbzkjrukmw }, {NULL, NULL} };
static const struct tscdjwilqjwi skcllfhlpccj[] = { { jydanxgomaxr, &mrwonjaoyxbs}, { jydanxgomaxr, &gamlankalzpw}, {NULL, NULL} };
static const struct tscdjwilqjwi bqiwlbylqrgm[] = { { jydanxgomaxr, &kbviwtefzoej}, { jydanxgomaxr, &vktvlyiogpma}, {jydanxgomaxr, &ufydlnhhmkua}, {NULL, NULL} };
static const struct tscdjwilqjwi xsscnakaqzvc[] = { { rstxotzjflzs, &mdjnqsoakvvf }, {NULL, NULL} };
static const struct tscdjwilqjwi fqzmzhyxhonn[] = { { jydanxgomaxr, &zsbpspxmkfgm}, { jydanxgomaxr, &kydcrfkjnwcm}, {NULL, NULL} };
static const struct tscdjwilqjwi tyjsurpbbyxy[] = { { jydanxgomaxr,	&kdybrquqbtuw }, { rstxotzjflzs,	&ufzjlbrakauk }, { rstxotzjflzs,	&btjbfgflehye }, { rstxotzjflzs,	&digouqolzees }, { rstxotzjflzs,	&tebpmszsjucy }, {NULL, NULL} };
static const struct tscdjwilqjwi tgposyylonet[] = { { fdeftqqvudxt, &zoysksjuvkfk}, {NULL, NULL} };
static const struct tscdjwilqjwi slupaugvfdqp[] = { { jydanxgomaxr, &zoysksjuvkfk}, {NULL, NULL} };
static const struct tscdjwilqjwi mwmcioyrqefl[] = { { jydanxgomaxr, &wwvdqqouxqkm}, { jydanxgomaxr, &vktvlyiogpma}, { jydanxgomaxr, &bxtwjhucrdoe}, {NULL, NULL} };
static const struct tscdjwilqjwi jwyiiycbiibg[] = { { jydanxgomaxr, &snbkbjaeynce}, { jydanxgomaxr, &txiiantrunvm}, {NULL, NULL} };
static const struct tscdjwilqjwi zlekbqquctli[] = { { jydanxgomaxr, &emzrnnfgmiwh}, { jydanxgomaxr, &suqahahsykbu}, { jydanxgomaxr, &jgmorpljogvl}, { jydanxgomaxr, &ijdhskvcbrqt}, {NULL, NULL} };
static const struct tscdjwilqjwi ykquefjrepxc[] = { { jydanxgomaxr, &emzrnnfgmiwh}, { jydanxgomaxr, &suqahahsykbu}, { jydanxgomaxr, &emzrnnfgmiwh}, { jydanxgomaxr, &ijdhskvcbrqt}, {NULL, NULL} };
static const struct tscdjwilqjwi mnmuaepxbiut[] = { { jydanxgomaxr, &emzrnnfgmiwh}, { jydanxgomaxr, &suqahahsykbu}, {NULL, NULL} };
static const struct tscdjwilqjwi yuaqzxesruem[] = { { jydanxgomaxr, &zacmsfrrmvko}, { jydanxgomaxr, &pujmfhdfaxtw}, {NULL, NULL} };
static const struct tscdjwilqjwi nnmhnxqpfemp[] = { { jydanxgomaxr, &hywmpzkxrwmu}, {NULL, NULL} };
static const struct tscdjwilqjwi bxppsphuomwg[] = { { dhkczohuuzns, &wmyyogvvnbfi}, {NULL, NULL} };
static const struct tscdjwilqjwi rcrfmcefxnvr[] = { { jydanxgomaxr, &vwszwdvovgeu}, { jydanxgomaxr, &mrwonjaoyxbs}, {NULL, NULL} };
static const struct tscdjwilqjwi zrcrmamyqgft[] = { { jydanxgomaxr,	&mdjnqsoakvvf }, { jydanxgomaxr,	&txiiantrunvm }, { jydanxgomaxr,	&mrwonjaoyxbs }, {NULL, NULL} };
static const struct tscdjwilqjwi bmzkvmhqnjyb[] = { { rstxotzjflzs, &wmyyogvvnbfi}, {NULL, NULL} };
static const struct tscdjwilqjwi odkkmzjhafwq[] = { { jydanxgomaxr, &byhmdqwjusjs }, { jydanxgomaxr, &dvgliryebcpe}, {NULL, NULL} };
#ifndef _NO_DEPRECATED
static const struct tscdjwilqjwi akblvvhzssfj[] = { { fjadgysdvbag, &zowzdurdsuvo}, {NULL, NULL} };
static const struct tscdjwilqjwi ovjvngnmawde[] = { { fjadgysdvbag, &ohjsargzzjsd}, {NULL, NULL} };
#endif
static const struct tscdjwilqjwi riqfffioqmin[] = { { rstxotzjflzs, &byhmdqwjusjs}, { jydanxgomaxr, &gamlankalzpw}, { NULL, NULL} };
static const struct tscdjwilqjwi zjpdowvsbula[] = { { jydanxgomaxr, &vktvlyiogpma}, { jydanxgomaxr, &dvgliryebcpe}, {NULL, NULL} };
static const struct tscdjwilqjwi upuorsdduhef[] = { { jydanxgomaxr, &hnxwiydrtykn}, { jydanxgomaxr, &xbvotpthfidh}, {NULL, NULL} };
static const struct tscdjwilqjwi qoirfytyezgn[] = { { dhkczohuuzns, &wmyyogvvnbfi}, { jydanxgomaxr, &vktvlyiogpma}, { jydanxgomaxr, &dvgliryebcpe}, {NULL, NULL} };
static const struct tscdjwilqjwi iyfkzmrxyuxz[] = { { jydanxgomaxr,	&mdjnqsoakvvf }, { jydanxgomaxr,	&lhjlwepmjtox }, { jydanxgomaxr,	&snbtlamfdfbc }, { jydanxgomaxr,	&mrwonjaoyxbs }, {NULL, NULL} };
static const struct tscdjwilqjwi yprgnfdcqslp[] = { { jydanxgomaxr, &kbviwtefzoej}, { rstxotzjflzs, &byhmdqwjusjs}, { jydanxgomaxr, &mrwonjaoyxbs}, { jydanxgomaxr, &gamlankalzpw}, {NULL, NULL} };
static const struct tscdjwilqjwi bwgirktvrhpn[] = { { rstxotzjflzs, &byhmdqwjusjs}, {NULL, NULL} };
static const struct tscdjwilqjwi yzbsxjngujtn[] = { { jydanxgomaxr, &rpxsbhryjmyq }, { jydanxgomaxr, &tnvnusdhkvia }, {NULL, NULL} };
static const struct tscdjwilqjwi tzmbteavenkv[] = { { dhkczohuuzns, &cdegkkkxwxme}, {NULL, NULL} };
static const struct tscdjwilqjwi onbpftrvfjfv[] = { { jydanxgomaxr,	&hfmdwrqmaktm }, { jydanxgomaxr,	&rpxsbhryjmyq }, { jydanxgomaxr,   &jpxjjmrlctlv }, {NULL, NULL} };
static const struct tscdjwilqjwi hpdybfucygic[] = { { jydanxgomaxr, &mqmqrbopdium}, {NULL, NULL} };
static const struct tscdjwilqjwi rlkwfmxievhz[] = { { dhkczohuuzns, &lsnjjydwsoaf}, { rstxotzjflzs, &hwbytmtnkjbv}, {NULL, NULL} };
static const struct tscdjwilqjwi zjckkaxrhoow[] = { { jydanxgomaxr, &dapmccgyyqaq}, {NULL, NULL} };
static const struct tscdjwilqjwi djyrdlmsgmez[] = { { rstxotzjflzs, &hwbytmtnkjbv}, {NULL, NULL} };
static const struct tscdjwilqjwi ervaejuksmrw[] = { { jydanxgomaxr,	&mcntaceapkic }, { jydanxgomaxr,	&nrlorrtmyius }, {NULL, NULL} };
static const struct tscdjwilqjwi iibwlluvqyeg[] = { { jydanxgomaxr,	&mdjnqsoakvvf }, { jydanxgomaxr,	&zzfssqgdagam }, {NULL, NULL} };
static const char* welxgepyuvqg[] = { "M96b (XIAOMI/TCL)", "M100b (SHINCO/SAMSUNG/ELECTROLUX)", "T102b (WHIRLPOOL/BOSCH/AIRWELL)", "M128b (FUJITSU/McQUAY/TICA)", "M56b (TRUMA)" };
static const bc7215FormatPkt_t zkzcieglrfln[] = { {{.inByte=0x34}, {0x14, 0x1d, 0x10, 0xfd, 0x14, 0x1d, 0x09, 0xfd, 0x9c, 0x9c, 0x12, 0x0a, 0x77, 0x9d, 0x38, 0xf8, 0x00, 0x00, 0xfa, 0x7f, 0xb5, 0x1a, 0x97, 0x02, 0x48, 0x00, 0x3e, 0x01, 0x48, 0x00, 0xea, 0x00}}, {{.inByte=0x35}, {0x13, 0x9D, 0x24, 0xDD, 0x13, 0x7D, 0x69, 0x3D, 0x9D, 0x1D, 0x2E, 0xDB, 0xF2, 0x9B, 0xBD, 0xFE, 0x0F, 0x02, 0xCE, 0x5F, 0x81, 0x3A, 0xA3, 0x22, 0x74, 0x00, 0x75, 0x05, 0x73, 0x00, 0x26, 0x13}}, {{.inByte=0x21}, {0x10, 0xBD, 0x06, 0x5D, 0x06, 0x5D, 0x2B, 0x9D, 0x1F, 0x19, 0x35, 0x4D, 0x1A, 0xA7, 0x72, 0xF9, 0x00, 0x00, 0x22, 0x00, 0x44, 0x00, 0x66, 0x90, 0x0D, 0x00, 0x0A, 0x00, 0x48, 0x00, 0x39, 0x00}}, {{.inByte=0x36}, {0x1B, 0x1D, 0x17, 0xFD, 0x18, 0xBD, 0x0F, 0xBD, 0x9F, 0x1E, 0x5F, 0x83, 0x83, 0xC9, 0x2B, 0xFB, 0x84, 0x00, 0x84, 0x10, 0x06, 0x01, 0x90, 0x02, 0x2D, 0x00, 0xF5, 0x08, 0x13, 0x02, 0x2F, 0x03}}, {{.inByte=0x37}, {0x15, 0xDD, 0x0C, 0x7D, 0x0C, 0x3D, 0x04, 0xFD, 0x1F, 0x9F, 0x92, 0x88, 0x19, 0x22, 0xCB, 0xF8, 0x00, 0x80, 0x00, 0x10, 0xA9, 0x9A, 0x8B, 0x82, 0x37, 0xC3, 0x81, 0x8A, 0x21, 0xE7, 0x01, 0x20}} };
static const uint8_t rahxtjoyxxhh[] = {0x60, 0x00, 0x9e, 0xc8, 0x00, 0x04, 0x52, 0x60, 0x00, 0x1c, 0x26, 0x10, 0x00, 0x4a};
static const uint8_t uldcokblewwr[] = {0x64, 0x00, 0x02, 0x05, 0x2C, 0x04, 0xD5, 0x56, 0x01, 0x6C, 0x50, 0xC4, 0x12, 0x40, 0x0C};
static const uint8_t djbkixrrrwet[] = {0x66, 0x00, 0x1C, 0x16, 0x00, 0x00, 0x87, 0x05, 0x80, 0x00, 0x21, 0xC1, 0x60, 0x00, 0x08};
static const uint8_t cbawxcfqfuna[] = {0x06, 0x01, 0x53, 0x04, 0x10, 0x04, 0x14, 0x10, 0x04, 0x00, 0x00, 0x04, 0x00, 0x04, 0x50, 0x10, 0x04, 0x14, 0x09, 0x00, 0x00, 0x00, 0x00, 0x50, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x50, 0x25};
static const uint8_t brmmxeltgjbu[] = {0x38, 0x00, 0xE9, 0x0D, 0x10, 0x00, 0x00, 0x00, 0x06};
static const uint8_t eanaachcpxpj[] = {0x60, 0x00, 0x9e, 0xc8, 0x00, 0x04, 0x52, 0x60, 0x00, 0x8c, 0x26, 0x10, 0x00, 0xda};
static const uint8_t ujhgzcxoiwsr[] = {0x64, 0x00, 0x02, 0x05, 0x2C, 0x04, 0xD5, 0x56, 0x01, 0x6C, 0x50, 0xD0, 0x12, 0x40, 0x0C};
static const uint8_t wjxsthsdbgmt[] = {0x66, 0x00, 0x1C, 0x14, 0x00, 0x00, 0x87, 0x05, 0x00, 0x00, 0x21, 0xC1, 0x40, 0x00, 0x08};
static const uint8_t qmespjmobqlw[] = {0x06, 0x01, 0x53, 0x04, 0x10, 0x04, 0x14, 0x10, 0x04, 0x00, 0x00, 0x04, 0x00, 0x04, 0x44, 0x10, 0x04, 0x10, 0x09, 0x00, 0x00, 0x00, 0x00, 0x50, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x50, 0x25};
static const uint8_t fmpkeshrsycv[] = {0x38, 0x00, 0xE9, 0x0D, 0x10, 0x00, 0x00, 0x00, 0x06};
static const bc7215DataVarPkt_t* ecmxlmscqqko[] = { (bc7215DataVarPkt_t*)eanaachcpxpj, (bc7215DataVarPkt_t*)ujhgzcxoiwsr, (bc7215DataVarPkt_t*)wjxsthsdbgmt, (bc7215DataVarPkt_t*)qmespjmobqlw, (bc7215DataVarPkt_t*)fmpkeshrsycv };
static const bc7215DataVarPkt_t* soccmyicelnf[] = { (bc7215DataVarPkt_t*)rahxtjoyxxhh, (bc7215DataVarPkt_t*)uldcokblewwr, (bc7215DataVarPkt_t*)djbkixrrrwet, (bc7215DataVarPkt_t*)cbawxcfqfuna, (bc7215DataVarPkt_t*)brmmxeltgjbu };
static const uint8_t ctsqslxbogzy = sizeof(ecmxlmscqqko)/sizeof(struct bc7215DataVarPkt_t*);
#ifndef _NO_DEPRECATED
static const uint8_t qeojruvmiqhg[] = {0x23, 0xCB, 0x26};
static const uint8_t izahqyxwrzzp[] = {0x02, 0x20, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x06};
#endif
static const uint8_t krnahgymqves[] = {0x28, 0x00, 0x68, 0xc2, 0x3d, 0x0f, 0x0f, 0x00, 0x00, 3, 1, 0xc0};
static const uint8_t dsljtuhftzxr[] = {0x28, 0x00, 0x68, 0xc2, 0x3d, 0x0f, 0xf0, 0x28, 0x00, 0x68, 0xb2, 0x4d, 0x0f, 0xf0, 3, 1, 0xc0, 3, 1, 0xb0};
static const uint8_t zzwrunrvqvjo[] = {0x48, 0x00, 0x1C, 0x28, 0x54, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x48, 0x00, 0x1C, 0x24, 0x49, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1a, 3, 1, 0x08, 3, 1, 0x04};
static const uint8_t syyzdovmflnp[] = {0x60, 0x00, 0x6A, 0xF5, 0x79, 0x20, 0x00, 0x53, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x4E, 0x60, 0x00, 0x6A, 0xF5, 0x79, 0x20, 0x00, 0x93, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x52, 3, 5, 0x40, 3, 5, 0x80};
static const uint8_t sjxdtrttjqul[] = {0x70, 0x00, 0x6A, 0x55, 0x79, 0x20, 0x00, 0x43, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x21, 0x00, 0x46, 0x70, 0x00, 0x6A, 0x55, 0x79, 0x20, 0x00, 0x83, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x21, 0x00, 0x4a, 3, 5, 0x40, 3, 5, 0x80};
static const uint8_t kmpfjdorsqvu[] = {0x00, 0x00, 0x36, 0x1B, 0x5D, 0x12, 0x3D, 0x1B, 0x7D, 0x02, 0x9D, 0x1F, 0x9E, 0x21, 0x60, 0x06, 0x53, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x10, 0x30, 0x00, 0x21, 0x0F, 0xC6, 0x0F, 0x20, 0x0F, 0xC6, 0x0F, 0x3F, 0x50, 0x60, 0x00, 0x4d, 0xb2, 0xde, 0x21, 0x07, 0xf8, 0x4d, 0xb2, 0xde, 0x21, 0x07, 0xf8, 0x00, 0x00};
static const uint8_t cdznnwdwivsn[] = {0x00, 0x00, 0x36, 0x1A, 0x1D, 0x13, 0x1D, 0x1A, 0x1D, 0x01, 0x3D, 0x1F, 0x9E, 0x37, 0xB5, 0x07, 0x07, 0x4C, 0xFB, 0x00, 0x00, 0x38, 0x10, 0x38, 0x00, 0x94, 0xE2, 0x28, 0xA3, 0x9E, 0xEA, 0x3E, 0x87, 0x0D, 0x0A, 0x70, 0x00, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x22, 0xff, 0x01, 0xa0, 0x11, 0xc0, 0x00, 0x00 };
static const uint8_t mfsnqiyfomas[] = {0x00, 0x00, 0x36, 0x15, 0xBD, 0x12, 0xFD, 0x15, 0x5D, 0x03, 0x9D, 0x1F, 0x9E, 0x23, 0x61, 0x08, 0x4F, 0xAA, 0xF8, 0x00, 0x00, 0x90, 0x10, 0x90, 0x00, 0x4E, 0x0F, 0x39, 0x0F, 0x31, 0x0F, 0x36, 0x0F, 0xFF, 0x4D, 0x20, 0x01, 0x4F, 0xB0, 0x30, 0xCF, 0x90, 0x2E, 0x20, 0x80, 0x70, 0xAA, 0x10, 0xDA, 0x40, 0x84, 0xD6, 0x84, 0xAE, 0x36, 0x4F, 0xB0, 0x30, 0xCF, 0x90, 0x2E, 0x20, 0x80, 0x70, 0xAA, 0x10, 0xDA, 0x40, 0x84, 0xD6, 0x84, 0xAE, 0x36, 0x00, 0x00};
static const uint8_t udfkhxapkpoi[] = {0x00, 0x00, 0x36, 0x15, 0x9D, 0x12, 0xDD, 0x15, 0x9D, 0x02, 0x1D, 0x1F, 0x9E, 0x22, 0x63, 0x08, 0x51, 0xAA, 0xF8, 0x00, 0x00, 0x30, 0x10, 0x30, 0x00, 0x4C, 0x0F, 0x0F, 0x0F, 0x4C, 0x0F, 0xBE, 0x0F, 0xFF, 0x4D, 0x60, 0x00, 0x4D, 0xB2, 0xDE, 0x21, 0x07, 0xF8, 0x4D, 0xB2, 0xDE, 0x21, 0x07, 0xF8, 0x00, 0x00};
static const uint8_t ryxvgwnhvhqj[] = {0xB8, 0x00, 0x01, 0x10, 0x00, 0x40, 0xbf, 0xff, 0x00, 0xe6, 0x19, 0x89, 0x76, 0x01, 0xfe, 0x3f, 0xc0, 0x29, 0xd6, 0x16, 0xe9, 0x01, 0xfe, 0xa0, 0x5f, 0xb8, 0x00, 0x01, 0x10, 0x00, 0x40, 0xbf, 0xff, 0x00, 0xe6, 0x19, 0x89, 0x76, 0x01, 0xfe, 0x3f, 0xc0, 0x29, 0xd6, 0x16, 0xe9, 0x01, 0xfe, 0x90, 0x6f, 3, 21, 0x20};
static const uint8_t rgdmzmthtvcf[] = {0x00, 0x00, 0x33, 0x1A, 0x1D, 0x13, 0x1D, 0x1A, 0x1D, 0x01, 0x3D, 0x1E, 0x9B, 0x19, 0x9F, 0x2A, 0xA8, 0x07, 0x31, 0x00, 0x80, 0x00, 0x10, 0x38, 0x20, 0x38, 0x10, 0x70, 0x20, 0x70, 0x10, 0x3E, 0x87, 0x30, 0x00, 0xa8, 0x00, 0x02, 0xb2, 0x0f, 0x00, 0x00, 0x00, 0xc0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0xff, 0x71, 0x80, 0x11, 0xc0, 0xa8, 0x00, 0x02, 0x92, 0x0f, 0x00, 0x00, 0x00, 0xf0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0xe2, 0xfe, 0x71, 0x80, 0x11, 0xf0, 3, 1, 0x20};
static const uint8_t qzlestjjkptx[] = {0x00, 0x00, 0x30, 0x1A, 0xDD, 0x13, 0xBD, 0x1A, 0x7D, 0x01, 0x9D, 0x1F, 0x98, 0x37, 0xB0, 0x07, 0x2B, 0xAA, 0xF8, 0x00, 0x00, 0x38, 0x10, 0x38, 0x00, 0x70, 0x10, 0x70, 0x00, 0x9E, 0x4A, 0x3E, 0x27, 0x39, 0x0D  , 0xa8, 0x00, 0x02, 0xb2, 0x0f, 0x00, 0x00, 0x00, 0xc0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0xff, 0x71, 0x80, 0x11, 0xc0, 0xa8, 0x00, 0x02, 0x92, 0x0f, 0x00, 0x00, 0x00, 0xf0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0xe2, 0xfe, 0x71, 0x80, 0x11, 0xf0, 3, 1, 0x20};
static const uint8_t ffcerrqtjhps[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x80, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x09, 0x30, 0xa1, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0e};
static const uint8_t yfkuaqiajgga[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x78, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfc, 0x08, 0x30, 0x91, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3e};
static const uint8_t ajschknuvcit[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x90, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x0b, 0x41, 0x89, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x03, 0x20};
static const uint8_t izottdwpooou[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x08, 0x01, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x1a, 0x40, 0x89, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x10, 0x24, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0x00, 0xac};
static const uint8_t jipcobyqakur[] = {0x30, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0x78, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfc, 0x08, 0x30, 0x91, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3e};
static const uint8_t zlaowtvkwyqg[] = {0x20, 0x00, 0x14, 0xeb, 0xc1, 0x3e, 0x40, 0x00, 0x14, 0xeb, 0x98, 0x91, 0x04, 0x00, 0x00, 0x00};
static const pcyrpcjthqnx jhgvzparnlca = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx mpxkolfltkzv = {.set={0x14, 0x0f, 0x10, 0x24, 0x13, 0x24, NULL}};
static const pcyrpcjthqnx whruaislmreg = {.set={0x14, 0x0f, 0x10, 0x24, 0x13, 0x24, drzwxvahkqog}};
static const pcyrpcjthqnx xgllypiasniq = {.set={0x13, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx esgmpidllgfz = {.set={0x10, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx yynjrgvifofa = {.set={0x10, 0x24, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx scyiucjgldru = {.set={0x14, 0x00, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx zmyyggphojsb = {.set={0x92, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx hzjwteowunqn = {.set={0x91, 0x2f, 0x10, 0x20, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx lfnxdvxbhkno = {.set={0x10, 0x0f, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx xecclojwxifk = {.set={0x10, 0x00, 0x14, 0x00, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx euzeynhxvmvh = {.set={0x10, 0x0f, 0x13, 0x0f, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx yiencdduerag = {.set={0x10, 0x00, 0x13, 0x00, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx qwfpgqtmwtko = {.set={0x13, 0x0f, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx spfrowmmitpj = {.set={0x10, 0x00, 0x13, 0x0f, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx gbquyuntkjcj = {.set={0x13, 0x20, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx cqvmenntifmu = {.set={0x10, 0x0f, 0x14, 0x00, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx qgykejxdlosa = {.set={0x13, 0x0f, 0x13, 0x20, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx nppopsfvalpj = {.set={0x13, 0x0f, 0x14, 0x01, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx ucyclyhzfvad = {.set={0x92, 0x0f, 0x13, 0x24, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx zgzeymoyuqug = {.set={0x10, 0x00, 0x13, 0x00, 0x13, 0x20, NULL}};
static const pcyrpcjthqnx hjvfjrpmdwha = {.set={0x10, 0x00, 0x92, 0x02, 0x13, 0x20, NULL}};
static const pcyrpcjthqnx wtvxxcpnyuur= {.set={0x10, 0x0f, 0x92, 0x40, 0x92, 0x21, NULL}};
static const pcyrpcjthqnx ydmusricyayh = {.set={0x30, 0x2f, 0x31, 0x2f, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx tdahwsjwfltg = {.set={0x72, 0x2f, 0x32, 0x24, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx tjoaocohphij = {.set={0x72, 0x1f, 0x72, 0x2f, 0xf0, 0xf0, NULL}};
static const pcyrpcjthqnx tabjnpfhkkyn = {.set={0x14, 0x0f, 0x10, 0x0f, 0xf0, 0xf0, htjvzcxgmuwg}};
static const pcyrpcjthqnx jbcfmenjdtsp= {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, tckdhaapiytx}};
static const pcyrpcjthqnx xkwrwveekrei = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, metvmlczjlbx}};
static const pcyrpcjthqnx hmssgkytopvh = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, sksefqpnsbpt}};
static const pcyrpcjthqnx rykgwspogprv = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, qmlivvmaaezt}};
static const pcyrpcjthqnx pblgptzotsfz = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, fxbyvijzoajk}};
static const pcyrpcjthqnx elqzgtnjohpm = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, xvujqrwzdojm}};
static const pcyrpcjthqnx ifqohpdojgmw = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, yozcdjtqyuxk}};
static const pcyrpcjthqnx zlhnhpkdjhtz = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, waepijeoeuud}};
static const pcyrpcjthqnx mraeclcavsoh = {.set={0x13, 0x0f, 0x13, 0x20, 0xf0, 0xf0, fgaohgcqksxl}};
static const pcyrpcjthqnx krhvlwzzqgbe = {.set={0x91, 0x2f, 0x91, 0x09, 0xf0, 0xf0, pjccakbandbw}};
static const pcyrpcjthqnx fyjtzzptjzpp = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, ibctvbkbutlc}};
static const pcyrpcjthqnx aaigbdzuflwz = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, psiaihyriooe}};
static const pcyrpcjthqnx ipmacjxmykvo = {.set={0x13, 0x20, 0xf0, 0xf0, 0xf0, 0xf0, apazjgfibbth}};
#ifndef _NO_DEPRECATED
static const struct opvdfjyhetkm ndrzsrhbrnpz;
static const struct opvdfjyhetkm azjipphwuwmd;
static const struct opvdfjyhetkm mihakphesbcl;
static const struct opvdfjyhetkm jazolpmdpfoh;
static const struct opvdfjyhetkm urhvwvrbxzdd;
static const struct opvdfjyhetkm uoexdvqutnft;
static const struct opvdfjyhetkm mnshgudisetv;
static const struct opvdfjyhetkm pxhubafgllji;
static const pcyrpcjthqnx myzdivzotfzc = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const ebbynksakqwk*)&ndrzsrhbrnpz}};
static const pcyrpcjthqnx nlkptvwjojnp = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const ebbynksakqwk*)&azjipphwuwmd}};
static const pcyrpcjthqnx umudfdkvwjjd = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const ebbynksakqwk*)&mihakphesbcl}};
static const pcyrpcjthqnx vfpmbmksdigg = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const ebbynksakqwk*)&jazolpmdpfoh}};
static const pcyrpcjthqnx uckbcozwnjsc = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const ebbynksakqwk*)&urhvwvrbxzdd}};
static const pcyrpcjthqnx nrdxswsbteli = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const ebbynksakqwk*)&uoexdvqutnft}};
static const pcyrpcjthqnx bgmbhviuwehp = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const ebbynksakqwk*)&mnshgudisetv}};
static const pcyrpcjthqnx gmpslrmizinl = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const ebbynksakqwk*)&pxhubafgllji}};
#endif
static const pcyrpcjthqnx xngvkmihdcmq = {.tihyumdayysw={82, 13, 0, 0}};
static const struct jzrjinarvghn pvbmujsajrfc = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 134, {35,32,35,32}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0, 0, 0x07, 0, cmsxvrymmhuq }, { 0x83, 2, 0x70, 4, vhrvrcongycf }, { 0, 0, 0x30, 4, dwqnirrjvvex }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, ogvkjsflqazm, &ksdjjvlyxnos };
static const struct jzrjinarvghn ilvymvgggkow = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 67, {35,32,0,0}, { 0, 1, 0x0f, 0, buapomigirnj}, { 0, 0, 0x07, 0, cmsxvrymmhuq}, { 0, 0, 0x30, 4, jfhuyfcvnpxj}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, dkyhokjcdqxy, &ksdjjvlyxnos };
static const struct jzrjinarvghn lmhexsamiflb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, buapomigirnj}, { 0, 0, 0x07, 0, cmsxvrymmhuq}, { 0, 0, 0x30, 4, jfhuyfcvnpxj}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn apqjwblvlscx = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 216, {64,152,0,0}, { 1, 6, 0x1E, 1, buapomigirnj }, { 1, 5, 0x70, 4, thzgkhzxcbmo }, { 1, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vxnzxedmpzzq, &kstbpyogoqfc };
static const struct jzrjinarvghn wkmqrlymjyed = { {0, 0, 0 , 0, 0, 0, 0}, 0x34, 43, {43,0,0,0}, { 0, 1, 0x0f, 0, buapomigirnj}, { 0, 0, 0x07, 0, cmsxvrymmhuq}, { 0, 0, 0x70, 4, ptyajwmvabif}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 9}, 3, 0x70}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn dninvymxmyrr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, dvnqveurzgme}, { 0, 0, 0x07, 0, cjitotwwwapg}, { 0, 0, 0x30, 4, ebyvbnhclkti}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn heqgejdnnetb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, dvnqveurzgme}, { 0, 0, 0x07, 0, qxpgycjvroxx}, { 0, 0, 0x30, 4, jfhuyfcvnpxj}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn bkbcyciovdgk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, buapomigirnj}, { 0, 0, 0x07, 0, qxpgycjvroxx}, { 0, 0, 0x30, 4, jfhuyfcvnpxj}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn xdaogblcbnft = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, buapomigirnj}, { 0, 0, 0x07, 0, qxpgycjvroxx}, { 0, 0, 0x30, 4, ebyvbnhclkti}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn vctlqrvgvigt = { {0, 1, 0, 0, 0, 1, 0}, 0x36, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, buapomigirnj}, { 0, 1, 0x07, 0, cmsxvrymmhuq}, { 0, 1, 0x30, 4, jfhuyfcvnpxj}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, plcxwpkkyrso, NULL };
#ifndef _NO_DEPRECATED
static const struct opvdfjyhetkm azjipphwuwmd = {NULL, &vctlqrvgvigt, 1, 255};
#endif
static const struct jzrjinarvghn dztwkxkfoauw = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 2, 0x0f, 0, buapomigirnj}, { 0, 1, 0x07, 0, cmsxvrymmhuq}, { 0, 1, 0x30, 4, jfhuyfcvnpxj}, { 0x80, 0, 0, 0, NULL},
#ifndef _NO_DEPRECATED
&nlkptvwjojnp,
#else
&jhgvzparnlca,
#endif
{.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, aijmlnqbomlg, NULL };
static const struct jzrjinarvghn txtbvqixrhxi = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 1, 0xf8, 3, vhizigxvykgi}, { 0, 6, 0xe0, 5, qttzvwrerooe}, { 0, 4, 0xe0, 5, wmyxfyxnffbi}, { 0, 11, 0x07, 0, qzwhrrwdagpl}, &tabjnpfhkkyn, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 9, 0x20}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &jwjyngpvzboh };
static const struct jzrjinarvghn xlgopwqmcfvp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 1, 0xf8, 3, vhizigxvykgi}, { 0, 6, 0xe0, 5, qttzvwrerooe}, { 0, 4, 0xe0, 5, alhwfibwmfss}, { 0, 11, 0x07, 0, qzwhrrwdagpl}, &tabjnpfhkkyn, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 9, 0x20}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn qvotqxdvaist = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 8, 0xff, 0, vswmkyynasya}, { 0, 0, 0xf0, 4, mxxtrfhnirvy}, { 0, 9, 0x03, 0, jfhuyfcvnpxj}, { 0, 0, 0x07, 0, wuysvezuukak}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn sqpbazfxatce = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 144, {72, 72, 0, 0}, { 0, 5, 0xf0, 4, dvnqveurzgme}, { 0, 6, 0x07, 0, ihjrlajmuzrx}, { 0, 6, 0xC0, 6, jfhuyfcvnpxj}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 6, 0x06}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, hjantykpakiw, NULL };
static const struct jzrjinarvghn ltaqmbndxryb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 1, 0x1f, 0, xpqyqvwgavtb }, { 0, 4, 0x70, 4, vcivvmmghbqr }, { 0, 4, 0x03, 0, gsqfyunwsqrs }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 5, 0xc0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, erextstztpbc, &phxfdngjxtxh };
static const struct jzrjinarvghn rqxbmkhftkme = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, vudrgutquhxw }, { 0, 6, 0x0f, 0, xsobwwhnqyha }, { 0, 8, 0x07, 0, dckrcgbseruo }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &rmukxbrpyiei };
static const struct jzrjinarvghn mvyctzucpqog = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, vudrgutquhxw }, { 0, 6, 0x0f, 0, xsobwwhnqyha }, { 0, 8, 0x07, 0, dckrcgbseruo }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &vkaqzunjzdxb };
static const struct jzrjinarvghn qgegepurwkmq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, tnufdxsbnpga }, { 0, 6, 0x0f, 0, xsobwwhnqyha }, { 0, 8, 0x07, 0, dckrcgbseruo }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn limefgaolscg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, vudrgutquhxw }, { 0, 6, 0x0f, 0, xsobwwhnqyha }, { 0, 8, 0x07, 0, kluzjnygjpga }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &ergisiglpktl };
static const struct jzrjinarvghn aepdmkpyeiok = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, xzocgzcmewun }, { 0, 6, 0x0f, 0, xsobwwhnqyha }, { 0, 8, 0x07, 0, kluzjnygjpga }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn cilgyidcbwrs = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, vudrgutquhxw}, { 0, 2, 0x07, 0, pbacsnxpcpud}, { 0, 0, 0xe0, 5, jtjkfvrgwjiz}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn kjatafbipoic = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, zzeskvulnbnl}, { 0, 2, 0x07, 0, iubiooqdloyk}, { 0, 0, 0xe0, 5, qlpcayadfusx}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn xfvjbtdpjjez = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, zzeskvulnbnl}, { 0, 2, 0x07, 0, pbacsnxpcpud}, { 0, 0, 0xC0, 6, vubnovfywcwm}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn iwtorypskysb = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, zzeskvulnbnl}, { 0, 2, 0x07, 0, iubiooqdloyk}, { 0, 0, 0xC0, 6, vubnovfywcwm}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn lvhzteagbvmh = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, zzeskvulnbnl}, { 0, 2, 0x0f, 0, vbrzlgamavar}, { 0, 0, 0xff, 0, ukppnpztqolj}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn kzegjqujbufa = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, zzeskvulnbnl}, { 0, 2, 0x07, 0, iubiooqdloyk}, { 0, 0, 0xe0, 5, pfrbvodoyvyl}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn bwtgxoxaslxp = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 4, 0x0f, 0, snifltmhdyyp }, { 0, 4, 0x30, 4, mtmsqrrolvof }, { 0, 2, 0x07, 0, ezynxglgampz }, { 0, 0, 0, 0, NULL}, &mpxkolfltkzv, {.buhyvlrkmues.oeiaiwqhculr = {{0, 8}, 2, 0xde}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 8}, 4, 0x07}}, ipxnzmfdaxjg, &ehwpreigzcax };
static const struct jzrjinarvghn gqpjzithfcoj = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 160, {56, 104, 0, 0}, { 1, 9, 0xFE, 1, hkpjcpgsdhqe }, { 1, 5, 0x70, 4, qygwxvpkgfvt }, { 1, 10, 0x0f, 0, jawjcodvnury }, { 0, 0, 0, 0, NULL}, &xgllypiasniq, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vxnzxedmpzzq, NULL };
static const struct jzrjinarvghn vbiehzleeabs = { {0, 1, 0, 0 ,0, 0, 0}, 0x36, 216, {64, 152, 0, 0}, { 1, 6, 0xfe, 1, ztllrbdaneil }, { 1, 5, 0x70, 4, thzgkhzxcbmo}, { 1, 8, 0xf0, 4, jawjcodvnury}, { 0, 0, 0, 0, NULL}, &xgllypiasniq, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, jgsneyvxdfad, &urxsveyojyse };
static const struct jzrjinarvghn wqgvzlptloyy = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfe, 1, ztllrbdaneil }, { 3, 5, 0x70, 4, thzgkhzxcbmo }, { 3, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL }, &xgllypiasniq, {.buhyvlrkmues.oeiaiwqhculr = {{3, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{3, 9}, 9, 0x0f}}, jfvkocmnqbrv, &zqreiqtujjyx };
static const struct jzrjinarvghn yqsawaquvssz = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 128, {128, 0, 0, 0}, { 0, 0x83, 0xff, 0, vswmkyynasya }, { 0, 1, 0x70, 4, cmsxvrymmhuq }, { 0, 2, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &esgmpidllgfz, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x0f}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, rymrjfuchium, NULL };
static const struct jzrjinarvghn fjjluaenjxsw = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 128, {128, 0, 0, 0}, { 0, 0x83, 0xff, 0, vswmkyynasya }, { 0, 1, 0x70, 4, cmsxvrymmhuq }, { 0, 2, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x0f}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, erextstztpbc, NULL };
static const struct jzrjinarvghn yjcegvrzyqki = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0x0f, 0, buapomigirnj }, { 0, 0, 0x70, 4, pklbbmlqtnff }, { 0, 1, 0x30, 4, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 1}, 0, 0x07}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn mfyphkdocbrg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0x0f, 0, efnrwobuqwkq }, { 0, 0, 0x70, 4, pklbbmlqtnff }, { 0, 1, 0x70, 4, qnnwjpvrdhrf }, { 0, 0, 0x0f, 0, sylyeogpaciw }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 1}, 0, 0x07}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn sdplgjulsshq = { {1, 1, 0, 0, 0, 0, 0}, 0x35, 80, {40, 40, 0, 0}, { 0, 0x1, 0xff, 0, vswmkyynasya }, { 0x00, 0, 0x07, 0, lxuqcjfntbsi }, { 0, 0, 0x30, 6, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0,8},1,0x16}}, ihdgkvsrxzad, NULL };
static const struct jzrjinarvghn ttvzvpazowgj = { {0, 1, 0, 0, 0, 0, 0}, 0x35, 80, {40, 40, 0, 0}, { 0, 0x1, 0xff, 0, vswmkyynasya }, { 0x00, 0, 0x07, 0, lxuqcjfntbsi }, { 0, 0, 0x30, 6, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0,8},1,0x16}}, ihdgkvsrxzad, NULL };
#ifndef _NO_DEPRECATED
static const struct opvdfjyhetkm mihakphesbcl = {NULL, &sdplgjulsshq, 1, 165};
#endif
static const struct jzrjinarvghn qailxirqucha = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0xff, 0, vswmkyynasya }, { 0, 0, 0x07, 0, lxuqcjfntbsi }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0x80, 0, 0, 0, NULL },
#ifndef _NO_DEPRECATED
&umudfdkvwjjd,
#else
&jhgvzparnlca,
#endif
{.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0,8},1,0x16}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn wugujjtnqjpn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 0x1, 0x0f, 0, efnrwobuqwkq }, { 0, 2, 0x60, 5, cmsxvrymmhuq }, { 0, 3, 0xc0, 6, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn kbaazfskvgmp = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 0x0, 0xff, 0, ujxifiqbxphx }, { 0, 4, 0xf0, 4, pvebvnyxmsjp }, { 0, 7, 0x0f, 0, xbwcusrxrcan }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, rltpttnrtiql, NULL };
static const struct jzrjinarvghn epmrjcsnvntz = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 64, {32,32,0,0}, { 0, 2, 0x0f, 0, buapomigirnj }, { 0, 0, 0x0f, 0, nhcoukbfzrjz }, { 0, 2, 0xf0, 4, mnodakhfdznk }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, djhatmpsdxol, NULL };
static const struct jzrjinarvghn oqiojjyaezmf = { {0, 1, 0, 0, 0, 1, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, efnrwobuqwkq }, { 0x00, 2, 0x07, 0, nlniqgmvdxbq }, { 0, 0, 0xf0, 4, lznqwjxyjfkm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, nxoifrxfomfj, NULL };
static const struct jzrjinarvghn jtsanvkmqbzz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 0x2, 0x0f, 0, buapomigirnj }, { 0x00, 10, 0x07, 0, gwgdwghbwqvm }, { 0, 4, 0x70, 4, pghqauvtkryo }, { 0, 12, 0x07, 0, naxmogvhefcm }, &jbcfmenjdtsp, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 3, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, pwxhsnaxlgxu, NULL };
static const struct jzrjinarvghn vfipjbascnoi = { {1, 0, 1, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 4, 0xf0, 4, klivdfuuohck }, { 0x00, 4, 0x0c, 2, laauizjchfid }, { 0x80, 2, 0xe0, 5, vheteeuffbon }, { 2, 1, 0xff, 0, qcnhobjmfcnj }, &whruaislmreg, {.bvyweglqjedh = (const bc7215DataVarPkt_t*)kmpfjdorsqvu}, lxtlnqiehxur, &umxlthldjkug };
static const struct jzrjinarvghn rwxfewtjkqfb = { {1, 0, 1, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 4, 0xf0, 4, klivdfuuohck }, { 0x00, 4, 0x0c, 2, laauizjchfid }, { 0x80, 2, 0xe0, 5, jeguxfjmlkrc }, { 2, 1, 0xff, 0, wqnqkdgayepg }, &whruaislmreg, {.bvyweglqjedh = (const bc7215DataVarPkt_t*)kmpfjdorsqvu}, lxtlnqiehxur, NULL };
static const struct jzrjinarvghn howhgqyozbfp = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xf0, 4, wvgqbkzvzydd }, { 0x00, 1, 0x70, 4, cmsxvrymmhuq }, { 0x40, 3, 0xf0, 4, xbwcusrxrcan }, { 0, 3, 0x0f, 0, amwmfgbsqpoe }, &ydmusricyayh, {.bvyweglqjedh = (bc7215DataVarPkt_t*)krnahgymqves}, jgnjzpftugki, NULL };
static const struct jzrjinarvghn hnyokspadpsr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0x80, 0, 0x0f, 0, ylpxgwdlalzr }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 4, 0x40, 6, wqmhpphavexg }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn teqwqtbirgba = { {0, 1, 0, 0, 0, 0, 0}, 0x3e, 129, {64, 65, 0, 0}, { 0, 2, 0x1e, 1, buapomigirnj }, { 0x0, 1, 0x07, 0, eumsaxjuxcvb }, { 0, 1, 0x70, 4, mluwrubdgqry }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x30}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 5, 0xc0}}, tpgmfwwgbmas, NULL };
static const struct jzrjinarvghn exgpmfjlggqq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0x0, 0, 0x70, 4, qxpgycjvroxx }, { 0, 1, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0x07, 0, jjrxfgzjmkdk }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn lbribthvwtho = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0x0, 0, 0x70, 4, mhguofhwxuno }, { 0, 1, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 1}, 0, 0x0f}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn gunjycfemuqa = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 80, {80, 0, 0, 0}, { 0, 1, 0x0f, 0, efnrwobuqwkq }, { 0x0, 0, 0x70, 4, qxpgycjvroxx }, { 0, 1, 0x30, 4, ebyvbnhclkti }, { 0, 0, 0x07, 0, jjrxfgzjmkdk }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn qglkwdjpdrxu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0x0, 0, 0x70, 4, mhguofhwxuno }, { 0, 1, 0x30, 4, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 1}, 0, 0x0f}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn fnohhtsyvyih = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0x0, 0, 0x70, 4, qxpgycjvroxx }, { 0, 1, 0x30, 4, ebyvbnhclkti }, { 0, 0, 0x0f, 0, qmuiwdazijnf }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn fadklifndrvp = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 112, {16, 40, 16, 40}, { 1, 3, 0xf0, 4, buapomigirnj }, { 0x81, 0, 0xc0, 6, uzosnlekzntp }, { 1, 1, 0x30, 4, ebyvbnhclkti }, { 0, 0, 0xc0, 6, rfwbpvrasrck }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0xc0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 9}, 0, 0xc0}}, yprgnfdcqslp, NULL };
static const struct jzrjinarvghn hohyfktauume = { {0, 0, 1, 0, 0, 0, 0}, 0x37, 40, {40, 0, 0, 0}, { 0x40, 3, 0xf0, 4, buapomigirnj }, { 0x0, 1, 0x70, 4, cmsxvrymmhuq }, { 0, 3, 0xf0, 4, xbwcusrxrcan }, { 0, 3, 0x0f, 0, wmllmjfukgvx }, &tdahwsjwfltg, {.bvyweglqjedh = (bc7215DataVarPkt_t*)dsljtuhftzxr}, jgnjzpftugki, NULL };
static const struct jzrjinarvghn wtcwmvqkihxu = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0x0f, 0, pvvpzdjqjogi }, { 0x0, 3, 0x70, 4, ihjrlajmuzrx }, { 0, 2, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &yiencdduerag, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn jidjptjpkyvw = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 7, 0xe0, 5, qttzvwrerooe }, { 0, 5, 0xe0, 5, wmyxfyxnffbi }, { 0, 12, 0x07, 0, qzwhrrwdagpl }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &uwqtblpoevgw };
static const struct jzrjinarvghn arqketchrbws = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 160, {112, 48, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 7, 0xe0, 5, qttzvwrerooe }, { 0, 5, 0xe0, 5, wmyxfyxnffbi }, { 0, 12, 0x07, 0, qzwhrrwdagpl }, &xkwrwveekrei, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 9}, 10, 0x10}}, jgsneyvxdfad, NULL };
static const struct jzrjinarvghn vpfgdiwqfyko = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 160, {112, 48, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 7, 0xe0, 5, qttzvwrerooe }, { 0, 5, 0xe0, 5, wmyxfyxnffbi }, { 0, 12, 0x07, 0, qzwhrrwdagpl }, &hmssgkytopvh, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 9}, 10, 0x10}}, jgsneyvxdfad, NULL };
static const struct jzrjinarvghn ynhzkuggekpp = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 0x1, 0xf0, 4, buapomigirnj }, { 0x0, 6, 0xf0, 4, ygoapywbiski }, { 0, 5, 0xc0, 6, ebyvbnhclkti }, { 0, 1, 0x07, 0, irqvpooglygo }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &vruhyldxsqcg };
static const struct jzrjinarvghn ywsajswcvpha = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 136, {112, 24, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 7, 0xe0, 5, qttzvwrerooe }, { 0, 5, 0xe0, 5, wmyxfyxnffbi }, { 0, 12, 0x07, 0, qzwhrrwdagpl }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0xc0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn gnwzgtsjbwwj = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 88, {88, 0, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 6, 0xe0, 5, xbpmeyfhhdfd }, { 0, 5, 0xe0, 5, vecxotamjvpz }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn vwqhhdqukkqh = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 88, {88, 0, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 6, 0xe0, 5, xbpmeyfhhdfd }, { 0, 4, 0xe0, 5, wmyxfyxnffbi }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bbemswosojno, NULL };
static const struct jzrjinarvghn pvbehcbgjdqh = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, buapomigirnj }, { 0x0, 5, 0x70, 4, rdeqmerohqwm }, { 0, 4, 0x07, 0, flvavtvltprq }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 9}, 0, 0x02}}, eaktzverivka, NULL };
static const struct jzrjinarvghn vjdhnhdhetil = { {1, 1, 0, 0, 0, 0 ,0}, 0x37, 64, {16, 48, 0, 0}, { 1, 3, 0xf0, 4, buapomigirnj }, { 1, 5, 0xe0, 5, povojwkleomj }, { 1, 1, 0x30, 4, sozvxzursspb }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bwgirktvrhpn, NULL };
static const struct jzrjinarvghn hkbvjvvpaqta = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 4, 0xFF, 0, docfvhcjnlkz }, { 0, 5, 0xe0, 5, wmyxfyxnffbi }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0xc0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 8}, 12, 5}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn vmwasyntvuvd = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 7, 0xe0, 5, qttzvwrerooe }, { 0, 5, 0xe0, 5, wmyxfyxnffbi }, { 0, 12, 0x0f, 0, emudiiksgbgu }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 4, 0x2f}}, custvsouukow, NULL };
static const struct jzrjinarvghn mngebgplstkg = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 7, 0xe0, 5, qttzvwrerooe }, { 0, 5, 0xe0, 5, wmyxfyxnffbi }, { 0, 12, 0x0f, 0, emudiiksgbgu }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0xf0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 4, 6}}, rtigvasdcxyh, NULL };
static const struct jzrjinarvghn dmjdpxjikdab = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, buapomigirnj }, { 0x0, 2, 0x70, 4, vxfmuobwaakd }, { 0, 1, 0x30, 4, vubnovfywcwm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, scxswegaqvtf, NULL };
static const struct jzrjinarvghn jbgkslffrhdz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 136, {136, 0, 0, 0}, { 0, 0x46, 0xFF, 0, pcsfqhzugqfm }, { 0x0, 5, 0xf0, 4, oioinznmyywt }, { 0, 5, 0x0f, 0, xhmffyuubxmn }, { 0, 0, 0, 0, NULL }, &yynjrgvifofa, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 8, 0x20}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0}, 0, 0}}, pehmuunkplcs, NULL };
static const struct jzrjinarvghn afegitdsnvyj = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, efnrwobuqwkq }, { 0, 1, 0x07, 0, okmydbbbrxta }, { 0, 2, 0x07, 0, eqdjldrmitax }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0xc0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0}, 0, 0}}, yichzudprcmp, &kfbwofaaezuo };
static const struct jzrjinarvghn vcekpwgmgywy = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, vudrgutquhxw }, { 0x0, 8, 0xe0, 5, iubiooqdloyk }, { 0, 6, 0x60, 5, vubnovfywcwm }, { 0, 4, 0x07, 0, uokgijllkpiq }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 6, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 4, 0x07}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn aplxfmdwjgqi = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, vudrgutquhxw }, { 0x0, 8, 0xe0, 5, iubiooqdloyk }, { 0, 6, 0x60, 5, vubnovfywcwm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 6, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 4, 0x07}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn aaedijmibvbg = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, vudrgutquhxw }, { 0x0, 4, 0x07, 0, zhtiumtbaogx }, { 0, 6, 0x60, 5, vubnovfywcwm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 6, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 4, 0x07}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn ukoldirljcac = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, vudrgutquhxw }, { 0x0, 8, 0xe0, 5, iubiooqdloyk }, { 0, 6, 0xe0, 5, qlpcayadfusx }, { 0, 4, 0x07, 0, uokgijllkpiq }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 6, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 4, 0x07}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn xrtmskpmzrtr = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, ifrpcfykwsct }, { 1, 1, 0x07, 0, ayuhkekjgwmt }, { 1, 0, 0x03, 0, ebyvbnhclkti }, { 2, 1, 0xff, 0, fldzsomvzpdo }, &rykgwspogprv, {.buhyvlrkmues.oeiaiwqhculr = {{2, 9}, 4, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bpznxebmdobd, &qessrelebsqo };
static const struct jzrjinarvghn jrexyjtrfpme = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 112, {16, 96, 0, 0}, { 1, 1, 0xf0, 4, ifrpcfykwsct }, { 1, 1, 0x07, 0, ayuhkekjgwmt }, { 1, 0, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 3}, 0, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bftcpabbpwok, NULL };
static const struct jzrjinarvghn hqpdxipmpnvb = { {0, 1, 0, 0 ,0, 0 ,0}, 0x34, 184, {24, 160, 0, 0}, { 1, 3, 0xff, 0, wsjgegevakkb }, { 1, 0, 0x3f, 0, sewcretxotnw }, { 1, 1, 0xff, 0, qlvjgabjkkwe }, { 1, 16, 0xff, 0, vjvthdvdxyht }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bftcpabbpwok, NULL };
static const struct jzrjinarvghn hxuwpefwgrvn = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 3, 0xf0, 4, ifrpcfykwsct }, { 0, 3, 0x07, 0, ayuhkekjgwmt }, { 0, 2, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, &vruhyldxsqcg };
static const struct jzrjinarvghn uqrciehbxhja = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 3, 0xf0, 4, buapomigirnj }, { 0, 3, 0x07, 0, ayuhkekjgwmt }, { 0, 2, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct mnbpqhzlmcjq dbkdtngtkfoe = { .mfziljnihjsa = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 168, {24, 144, 0, 0}, { 1, 12, 0xfe, 1, gruhogprmszk }, { 1, 14, 0x0f, 0, wuzseaupzrze }, { 1, 14, 0xf0, 4, wpbkkaqyfnoq }, { 1, 8, 0x0f, 0, zqwdpzfdddbw }, &jhgvzparnlca, {.xhwercrymuhm = lsdnufbscnyj}, rfqbmelawvsm, &epgqggeumyzg }, .zogvzqcdcrgi = wuzseaupzrze };
static const struct jzrjinarvghn udbneafgmgtq = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 136, {24, 112, 0, 0}, { 0x41, 12, 0xfe, 1, gruhogprmszk }, { 0x61, 12, 0x0f, 0, (const uint8_t*)&dbkdtngtkfoe }, { 1, 12, 0xf0, 4, wpbkkaqyfnoq }, { 1, 8, 0x0f, 0, zqwdpzfdddbw }, &tjoaocohphij, {.bvyweglqjedh = (bc7215DataVarPkt_t*)ryxvgwnhvhqj}, rfqbmelawvsm, &epgqggeumyzg };
static const struct jzrjinarvghn osvqmokxbcge = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, xpqyqvwgavtb }, { 0, 4, 0x30, 4, uulmcnvnkhop }, { 0, 4, 0x03, 0, gsqfyunwsqrs }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 5, 0x40}}, erextstztpbc, &vruhyldxsqcg };
static const struct jzrjinarvghn icvzydwgywmn = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0xf0, 4, ifrpcfykwsct }, { 0, 3, 0x07, 0, ayuhkekjgwmt }, { 0, 2, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn gswdpuhyngdl = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0xf0, 4, ifrpcfykwsct }, { 0, 3, 0x07, 0, ayuhkekjgwmt }, { 0, 2, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &jmbhosevytxl };
static const struct jzrjinarvghn lmlntvlfgpaa = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, xpqyqvwgavtb }, { 0x80, 4, 0x30, 4, uulmcnvnkhop }, { 0, 4, 0x03, 0, gsqfyunwsqrs }, { 0, 2, 0xff, 0, hbwwkcufmgtw }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 5, 0x40}}, erextstztpbc, NULL };
static const struct jzrjinarvghn daadzbfpjoco = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0x0, 0, 0x70, 4, qxpgycjvroxx }, { 0, 1, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0x0f, 0, qmuiwdazijnf }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn isxmfxprujij = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, ifrpcfykwsct }, { 0x0, 0, 0x70, 4, qxpgycjvroxx }, { 0, 1, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0x0f, 0, qmuiwdazijnf }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn okudxoulzygm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0x1f, 0, xpqyqvwgavtb }, { 0x80, 4, 0x30, 4, eqtohjhdzall }, { 0, 4, 0x03, 0, gsqfyunwsqrs }, { 0, 2, 0x10, 4, mrzhghoduugz }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3},5, 0x04}}, rltpttnrtiql, &ehwpreigzcax };
static const struct jzrjinarvghn gdmumvajjiks = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, xpqyqvwgavtb }, { 0x80, 4, 0x30, 4, uulmcnvnkhop }, { 0, 4, 0x0c, 2, gsqfyunwsqrs }, { 0, 2, 0xff, 0, utibfbhrijim }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 5, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 9}, 5, 0x80}}, erextstztpbc, NULL };
static const struct jzrjinarvghn bpjfcghrplyk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0x1f, 0, xpqyqvwgavtb }, { 0x80, 4, 0x30, 4, uulmcnvnkhop }, { 0, 4, 0x03, 0, gsqfyunwsqrs }, { 0, 2, 0x10, 4, mrzhghoduugz }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 9}, 1, 0x02}}, rltpttnrtiql, NULL };
static const struct jzrjinarvghn utcbopooyjus = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, vudrgutquhxw }, { 0, 6, 0x0f, 0, xsobwwhnqyha }, { 0, 8, 0x07, 0, dckrcgbseruo }, { 0, 12, 0xff, 0, hpestlhbojnk}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &ngxafksruwje };
static const struct jzrjinarvghn xmbhknleeuxj = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 113, {113, 0, 0, 0}, { 0, 7, 0x0f, 0, vudrgutquhxw}, { 0, 6, 0x0f, 0, xsobwwhnqyha}, { 0, 8, 0x07, 0, dckrcgbseruo}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, lfpvkfuduvwy, NULL };
static const struct jzrjinarvghn ltkgkyaviwqy = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 168, {56, 56, 56, 0}, { 0, 5, 0x0f, 0, buapomigirnj }, { 0, 5, 0xf0, 4, vwwidqnxzalo }, { 0, 3, 0x03, 0, jfhuyfcvnpxj }, { 0, 5, 0x20, 5, alrnjjnrhabw }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, inwstcboizia, NULL };
static const struct jzrjinarvghn jffejbtfasnf = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, vudrgutquhxw }, { 0x80, 6, 0x0f, 0, xsobwwhnqyha }, { 0, 8, 0x07, 0, dckrcgbseruo }, { 0, 8, 0xf8, 0, sapgzpgkkkxd }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn jkaxjnaqefzl = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 168, {56, 56, 56, 0}, { 0, 5, 0x0f, 0, buapomigirnj }, { 0, 5, 0xf0, 4, givwidfmpulq }, { 0, 3, 0x03, 0, ebyvbnhclkti }, { 0, 5, 0x20, 5, alrnjjnrhabw }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, inwstcboizia, NULL };
static const struct jzrjinarvghn rpptlkdehakw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0xff, 0, dhkpixeqncfl }, { 0, 0, 0x07, 0, qxpgycjvroxx }, { 0, 2, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn xntydomqjghs = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x0f, 0, efnrwobuqwkq }, { 0, 0, 0x07, 0, qxpgycjvroxx }, { 0, 2, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn qcnnhftegxbd = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0, 0, 0x70, 4, qxpgycjvroxx }, { 0, 1, 0x30, 4, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 1}, 0, 0x87}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn eqqcxmgoacbk = { {1, 0, 0, 1, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 7, 0x1e, 1, buapomigirnj }, { 0, 5, 0x07, 0, cmsxvrymmhuq }, { 0, 6, 0xff, 0, ibsttytohvxf }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, pwxhsnaxlgxu, NULL };
static const struct jzrjinarvghn ishkxbxovmyf = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 224, {112, 112, 0, 0}, { 1, 7, 0x0f, 0, vudrgutquhxw }, { 1, 6, 0x0f, 0, xsobwwhnqyha }, { 0x81, 8, 0x07, 0, dckrcgbseruo }, { 0, 6, 0xe0, 5, yjqqxwzpxlsp }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1,9},5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0}, 0, 0}}, psunhpfbuibp, &mqlpzjonomrx };
static const struct jzrjinarvghn wcimpbpskbzn = { {1, 1, 0, 0, 0, 0, 0}, 0x35, 88, {44, 44, 0, 0}, { 0, 0x1, 0xff, 0, vswmkyynasya }, { 0x00, 0, 0x07, 0, lxuqcjfntbsi }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, ihdgkvsrxzad, NULL };
#ifndef _NO_DEPRECATED
static const struct opvdfjyhetkm jazolpmdpfoh = {NULL, &wcimpbpskbzn, 1, 165};
#endif
static const struct jzrjinarvghn futoxazegnjo = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 0x1, 0xff, 0, vswmkyynasya }, { 0x00, 0, 0x07, 0, lxuqcjfntbsi }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0x80, 0, 0, 0, NULL },
#ifndef _NO_DEPRECATED
&vfpmbmksdigg,
#else
&jhgvzparnlca,
#endif
{.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn mvjacrgmcqrk = { {1, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0xf0, 4, myxgzexwujuf }, { 0x00, 1, 0x0c, 2, fbxwaojofjhk }, { 0, 1, 0x03, 0, kzpnjyfxeljh }, { 0, 2, 0xf0, 4, eeighxiyxies }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,9},0,0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, vqqhqzfkmsnp, NULL };
static const struct jzrjinarvghn erzqxjwqllkw = { {1, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0xf0, 4, zzeskvulnbnl }, { 0x00, 1, 0x0c, 2, fbxwaojofjhk }, { 0, 1, 0x03, 0, kzpnjyfxeljh }, { 0, 2, 0xf0, 4, wxaiwoaahkwe }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,9},0,0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vqqhqzfkmsnp, NULL };
static const struct jzrjinarvghn kmsilceuotxy = { {1, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0xf0, 4, zzeskvulnbnl }, { 0x00, 1, 0x0c, 2, fbxwaojofjhk }, { 0, 1, 0x03, 0, kzpnjyfxeljh }, { 0, 2, 0xf0, 4, eeighxiyxies }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,9},0,0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vqqhqzfkmsnp, NULL };
static const struct jzrjinarvghn rvzizqwfxphi = { {1, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0xf0, 4, dvnqveurzgme }, { 0x00, 1, 0x0c, 2, fbxwaojofjhk }, { 0, 1, 0x03, 0, kzpnjyfxeljh }, { 0, 2, 0xf0, 4, wxaiwoaahkwe }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,9},0,0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vqqhqzfkmsnp, NULL };
static const struct jzrjinarvghn mlkbpgmieafx = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 288, {144, 144, 0, 0}, { 0, 7, 0x0f, 0, buapomigirnj }, { 0x80, 6, 0x38, 3, aebsjwjbaiod }, { 0, 9, 0x07, 0, ptyajwmvabif }, { 0, 8, 0x07, 0, pecawqoeugnp }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x20}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, oeaawphogzrs, &oytzpfcuaoer };
static const struct jzrjinarvghn mgegaqaudmeb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 144, {144, 0, 0, 0}, { 0, 7, 0x0f, 0, buapomigirnj }, { 0x80, 6, 0x38, 3, aebsjwjbaiod }, { 0, 9, 0x07, 0, ptyajwmvabif }, { 0, 8, 0x07, 0, pecawqoeugnp }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x20}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn ldvricuzlhei = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 184, {40, 144, 0, 0}, { 1, 7, 0x0f, 0, vudrgutquhxw }, { 0x1, 6, 0x07, 0, aebsjwjbaiod }, { 1, 8, 0x07, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, vxnzxedmpzzq, NULL };
static const struct jzrjinarvghn fgkokdzmpmbv = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 184, {40, 144, 0, 0}, { 1, 7, 0x0f, 0, buapomigirnj }, { 0x81, 6, 0x38, 3, xsobwwhnqyha }, { 1, 9, 0x03, 0, jfhuyfcvnpxj }, { 1, 8, 0x07, 0, pecawqoeugnp }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x20}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, vxnzxedmpzzq, &nqdrednjsqkh };
static const struct jzrjinarvghn ssmzuiojchvw = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 88, {24, 64, 0, 0}, { 1, 6, 0xf0, 4, kmdzdjlnsexa }, { 1, 6, 0x07, 0, iubiooqdloyk }, { 1, 4, 0xe0, 5, bzykmtaucpuj }, { 0, 0, 0, 0, NULL }, &xecclojwxifk, {.buhyvlrkmues.oeiaiwqhculr = {{1, 3}, 2, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{1,3},6,0x08}}, rfqbmelawvsm, NULL };
static const struct jzrjinarvghn ksgdnhnsejcu = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 136, {40, 48, 48, 0}, { 1, 1, 0xf0, 4, buapomigirnj }, { 1, 1, 0x07, 0, ysfpkhpowxhl }, { 1, 2, 0x06, 1, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, zbhtgmnquwwn, &irqsoswtdfbf };
static const struct jzrjinarvghn gfsmqnbrgxdm = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 136, {40, 48, 48, 0}, { 1, 0, 0x1e, 1, buapomigirnj }, { 1, 1, 0x07, 0, ysfpkhpowxhl }, { 1, 2, 0x06, 1, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, zbhtgmnquwwn, &kyneiszbvsip };
static const struct jzrjinarvghn fcbmwwygvzuj = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 102, {51, 51, 0, 0}, { 0, 2, 0xf0, 4, vudrgutquhxw }, { 0, 1, 0x0f, 0, xsobwwhnqyha }, { 0, 2, 0x07, 0, vhrvrcongycf }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x03}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, ihdgkvsrxzad, &flgqdjgdzxlp };
static const struct jzrjinarvghn wuawekcnekev = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 2, 0xf0, 4, zzeskvulnbnl }, { 0x0, 2, 0x07, 0, pbacsnxpcpud }, { 0, 0, 0x70, 4, zyknptsfnsch }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn kuccxgoytweu = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 6, 0xf0, 4, myxgzexwujuf }, { 1, 6, 0x07, 0, iubiooqdloyk }, { 1, 4, 0xe0, 5, bzykmtaucpuj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 3}, 6, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, rfqbmelawvsm, NULL };
static const struct jzrjinarvghn dbseuwxsoigd = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 6, 0xf0, 4, zzeskvulnbnl }, { 1, 6, 0x07, 0, iubiooqdloyk }, { 1, 4, 0xe0, 5, bzykmtaucpuj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 3}, 6, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, rfqbmelawvsm, NULL };
static const struct jzrjinarvghn wanfwuugxpdp = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 120, {24, 96, 0, 0}, { 1, 2, 0xf0, 4, zzeskvulnbnl }, { 1, 2, 0x07, 0, iubiooqdloyk }, { 1, 8, 0x18, 3, kzpnjyfxeljh }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, rfqbmelawvsm, NULL };
static const struct jzrjinarvghn inxntmuissfe = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 120, {24, 96, 0, 0}, { 1, 2, 0xf0, 4, zzeskvulnbnl }, { 1, 2, 0x07, 0, iubiooqdloyk }, { 1, 8, 0x18, 3, kzpnjyfxeljh }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, rfqbmelawvsm, NULL };
static const struct jzrjinarvghn xgkfploforqx = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 86, {43, 43, 0, 0}, { 0, 2, 0xf0, 4, vudrgutquhxw }, { 0x80, 0, 0x0c, 2, jldlbflzeltj }, { 0, 0, 0x30, 4, ebyvbnhclkti }, { 0, 4, 0x20, 5, hijfyumxdibt }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, ihdgkvsrxzad, NULL };
static const struct jzrjinarvghn qdwjilmfujck = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 84, {24, 56, 4, 0}, { 1, 1, 0xf0, 4, vudrgutquhxw }, { 1, 0, 0xe0, 5, znokwwctnkdq }, { 1, 2, 0x70, 4, dckrcgbseruo }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, zrgqgsknhgmg, NULL };
static const struct jzrjinarvghn vcnwkygcwhox = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {24, 64, 0, 0}, { 1, 6, 0xf0, 4, zzeskvulnbnl }, { 1, 6, 0x07, 0, iubiooqdloyk }, { 1, 4, 0xe0, 5, bzykmtaucpuj }, { 0, 0, 0, 0, NULL }, &scyiucjgldru, {.buhyvlrkmues.oeiaiwqhculr = {{1, 3}, 6, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, rfqbmelawvsm, NULL };
static const struct jzrjinarvghn ycntaxvuagcn = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 4, 0xf0, 4, zzeskvulnbnl }, { 0x0, 4, 0x07, 0, iubiooqdloyk }, { 0, 2, 0x70, 4, baiwoskalnfe }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0,3},4,0x08}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn pkozxtmdahpc = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 152, {24, 128, 0, 0}, { 1, 4, 0x0f, 0, zzeskvulnbnl }, { 1, 2, 0x07, 0, iubiooqdloyk }, { 1, 6, 0x07, 0, mcvnwlsxykch }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, rfqbmelawvsm, NULL };
static const struct jzrjinarvghn ebttfdlxpgxl = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 128, {128, 0, 0, 0}, { 0, 6, 0x3e, 1, xpqyqvwgavtb }, { 0, 5, 0xc0, 6, gwgdwghbwqvm }, { 0, 5, 0x0c, 2, gsqfyunwsqrs }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, nxtgxmvlmrlk, NULL };
static const struct jzrjinarvghn cedjyysahwcr = { {0, 1, 0, 0 ,0, 0, 0}, 0x31, 96, {32, 32, 32, 0}, { 0, 0, 0x0f, 0, efnrwobuqwkq }, { 0, 2, 0x07, 0, nlniqgmvdxbq }, { 0, 0, 0x70, 4, lznqwjxyjfkm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, xltcyqoqdczl, NULL };
static const struct jzrjinarvghn hnmelkjbfkcs = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {56, 120, 0, 0}, { 1, 10, 0x3e, 1, kgdzjljuqqgi }, { 1, 7, 0x70, 4, cgaowyvjwkxn }, { 1, 11, 0x70, 4, vhrvrcongycf }, { 1, 6, 0x04, 2, bdhbfkrydhri }, &pblgptzotsfz, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 7, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, jgsneyvxdfad, NULL };
static const struct jzrjinarvghn dbrrkrvscasz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 6, 0x3e, 1, xpqyqvwgavtb }, { 0, 5, 0xe0, 5, ejabjoghqrct }, { 0, 5, 0x0e, 1, jypmwbtvsryk }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, yflqywxlhtkc, &kstbpyogoqfc };
static const struct jzrjinarvghn xhrlrdsgofsy = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 56, {12, 44, 0, 0}, { 1, 3, 0x0f, 0, buapomigirnj }, { 1, 4, 0x07, 0, cmsxvrymmhuq }, { 1, 3, 0xe0, 5, gehvvnkxjrrg }, { 0, 0, 0, 0, NULL }, &yynjrgvifofa, {.bvyweglqjedh = (bc7215DataVarPkt_t*)cdznnwdwivsn}, mnmuaepxbiut, &wejtnopglwlg };
static const struct jzrjinarvghn fmgrvffxzvfc = { {0, 1, 1, 0, 0, 0, 0}, 0x31, 112, {12, 44, 12, 44}, { 3, 3, 0x0f, 0, buapomigirnj }, { 3, 4, 0x07, 0, cmsxvrymmhuq }, { 3, 3, 0xe0, 5, gehvvnkxjrrg }, { 0, 0, 0, 0, NULL }, &yynjrgvifofa, {.bvyweglqjedh = (bc7215DataVarPkt_t*)rgdmzmthtvcf}, zlekbqquctli, &xisdkgnxkbvl };
static const struct jzrjinarvghn qdrlsbrlhnox = { {0, 1, 1, 0, 0, 0, 0}, 0x36, 112, {12, 44, 12, 44}, { 3, 3, 0x0f, 0, buapomigirnj }, { 3, 4, 0x07, 0, cmsxvrymmhuq }, { 3, 3, 0xe0, 5, gehvvnkxjrrg }, { 0, 0, 0, 0, NULL }, &yynjrgvifofa, {.bvyweglqjedh = (bc7215DataVarPkt_t*)qzlestjjkptx}, zlekbqquctli, &xisdkgnxkbvl };
static const struct jzrjinarvghn fbvkagozgblg = { {0, 1, 1, 0, 0, 0, 0}, 0x37, 113, {12, 44, 13, 44}, { 3, 3, 0x1e, 1, buapomigirnj }, { 3, 4, 0x07, 0, cmsxvrymmhuq }, { 3, 3, 0xe0, 5, gehvvnkxjrrg }, { 0, 0, 0, 0, NULL }, &yynjrgvifofa, {.bvyweglqjedh = (bc7215DataVarPkt_t*)qzlestjjkptx}, ykquefjrepxc, &zvpcsdldazbs };
static const struct jzrjinarvghn aodjsvylqyfu = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xF0, 4, buapomigirnj }, { 1, 2, 0x07, 0, cmsxvrymmhuq }, { 1, 3, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)ffcerrqtjhps}, xhzoapezwhhv, &ehwpreigzcax };
static const struct jzrjinarvghn nlltmejzaquu = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 120, {56, 64, 0, 0}, { 1, 1, 0xF0, 4, buapomigirnj }, { 1, 2, 0x07, 0, cmsxvrymmhuq }, { 1, 3, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)yfkuaqiajgga}, xhzoapezwhhv, &ehwpreigzcax };
static const struct jzrjinarvghn zvvgzcuptmpq = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0xF0, 4, buapomigirnj }, { 0, 4, 0x07, 0, xdcmwtnyzghg }, { 0, 4, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)zlaowtvkwyqg}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn ljxdgwlfbbcd = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0xF0, 4, buapomigirnj }, { 0, 4, 0x0f, 0, ozbkbztauizz }, { 0, 4, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)zlaowtvkwyqg}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn gmqhochxbadi = { {0, 1, 0, 0, 0, 1, 0}, 0x34, 104, {40, 64, 0, 0}, { 1, 1, 0xfe, 1, gruhogprmszk }, { 1, 0, 0x0f, 0, mhihuyvkkslz }, { 1, 0, 0x70, 4, ptyajwmvabif }, { 0, 0, 0, 0, NULL }, &lfnxdvxbhkno, {.buhyvlrkmues.oeiaiwqhculr= {{1, 3}, 6, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, zrgqgsknhgmg, NULL };
static const struct jzrjinarvghn sfgzdfpfrntr = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 144, {56, 88, 0, 0}, { 1, 1, 0xF8, 3, vhizigxvykgi }, { 1, 2, 0x07, 0, cmsxvrymmhuq }, { 1, 3, 0x0f, 0, xnhgqaeimgrp }, { 1, 1, 0x01, 0, bdhbfkrydhri }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)ajschknuvcit}, xhzoapezwhhv, NULL };
static const struct jzrjinarvghn efjqotwzdbde = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 264, {56, 208, 0, 0}, { 1, 1, 0xF8, 3, vhizigxvykgi }, { 1, 2, 0x07, 0, cmsxvrymmhuq }, { 1, 3, 0x0f, 0, xnhgqaeimgrp }, { 1, 1, 0x01, 0, bdhbfkrydhri }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)izottdwpooou}, xhzoapezwhhv, NULL };
static const struct jzrjinarvghn blzdlbvzjblu = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 64, {48, 16, 0, 0}, { 0, 3, 0xFF, 0, vswmkyynasya }, { 0, 1, 0x0f, 0, yyrhmzcinojl }, { 0, 1, 0xf0, 4, lrzfiwrgsash }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 4, 0x40}}, xadzuaqodfvq, NULL };
static const struct jzrjinarvghn ldijdogdukeh = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xF8, 3, vhizigxvykgi }, { 1, 2, 0x07, 0, cmsxvrymmhuq }, { 1, 3, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)ffcerrqtjhps}, xhzoapezwhhv, NULL };
static const struct jzrjinarvghn xqgurcrczyec = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 264, {24, 240, 0, 0}, { 1, 10, 0x3c, 2, buapomigirnj }, { 1, 22, 0x07, 0, ebpakvtdyfdu }, { 1, 22, 0x70, 4, mipwiqvjrowq }, { 1, 8, 0xff, 0, gkvkeyennlqq }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 24, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, qqfbzpvygqkj, NULL };
static const struct jzrjinarvghn hygznuckhely = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 344, {24, 320, 0, 0}, { 1, 10, 0x3c, 2, buapomigirnj }, { 1, 22, 0x07, 0, ebpakvtdyfdu }, { 1, 22, 0x70, 4, mipwiqvjrowq }, { 1, 8, 0xff, 0, gkvkeyennlqq }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 24, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, qqfbzpvygqkj, NULL };
static const struct jzrjinarvghn yjxgivcmzqfq = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 224, {56, 168, 0, 0}, { 1, 4, 0x3e, 1, ztllrbdaneil }, { 1, 3, 0x0f, 0, rfomkxlybrfq }, { 1, 6, 0x07, 0, sgdqjyffemkq }, { 1, 2, 0x0f, 0, awqpbneofhcb }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 10, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, podkkiznmzjn, &vbuvvhmkolva };
static const struct jzrjinarvghn rfpjqvkvwpmw = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 296, {24, 272, 0, 0}, { 1, 10, 0x3c, 2, buapomigirnj }, { 1, 22, 0x0f, 0, iwvmyqnxkcuy }, { 1, 22, 0x70, 4, wvvnysigoaye }, { 1, 8, 0xff, 0, gkvkeyennlqq }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 24, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, qqfbzpvygqkj, NULL };
static const struct jzrjinarvghn vfjpdfhhswbj = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 40, {40, 0, 0, 0}, { 0, 3, 0x0f, 0, vudrgutquhxw }, { 0, 2, 0x07, 0, tfndsdmrabjz }, { 0, 2, 0x70, 4, baiwoskalnfe }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, awvsbtnwqzll, NULL };
static const struct jzrjinarvghn afxwpwzkwwrh = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0, 4, 0x70, 4, aetxomkagiah }, { 0, 4, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 8}, 5, 0x41}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn kfwreqkeeksk = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 317, {5, 160, 152, 0}, { 2, 6, 0xfe, 1, ztllrbdaneil }, { 2, 5, 0x70, 4, thzgkhzxcbmo }, { 2, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL }, &euzeynhxvmvh, {.buhyvlrkmues.oeiaiwqhculr = {{2, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{1, 3}, 11, 0x80}}, racwsrkxfair, &wtdilmafrcjz };
static const struct jzrjinarvghn aoktqrucczue = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 200, {56, 144, 0, 0}, { 1, 10, 0x3e, 1, kgdzjljuqqgi }, { 1, 7, 0x70, 4, ztxfusqfadqd }, { 1, 11, 0x70, 4, vhrvrcongycf }, { 1, 6, 0x04, 2, bdhbfkrydhri }, &qwfpgqtmwtko, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 7, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{1, 9}, 6, 0x04}}, jgsneyvxdfad, NULL };
static const struct jzrjinarvghn dvkewhqehvbw = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 157, {5, 152, 0, 0}, { 1, 6, 0xfe, 1, ztllrbdaneil }, { 1, 5, 0x70, 4, thzgkhzxcbmo }, { 1, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL }, &xgllypiasniq, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vxnzxedmpzzq, &urxsveyojyse };
static const struct jzrjinarvghn pnqnburnypaq = { {0, 1, 0, 0, 0, 1, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, buapomigirnj }, { 0x00, 2, 0x07, 0, nlniqgmvdxbq }, { 0, 0, 0xf0, 4, lznqwjxyjfkm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, nxoifrxfomfj, NULL };
static const struct jzrjinarvghn pdpbhpsrdzte = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, vswmkyynasya }, { 0, 1, 0x0F, 0, hhwccagaucle }, { 0, 1, 0xf0, 4, wkuwmuzlxyrc }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 7, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, yzghrprslect, NULL };
static const struct jzrjinarvghn ursiqadbboai = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 286, {6, 64, 64, 152}, { 3, 6, 0xfe, 1, ztllrbdaneil }, { 3, 5, 0x70, 4, thzgkhzxcbmo }, { 3, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL }, &spfrowmmitpj, {.buhyvlrkmues.oeiaiwqhculr = {{3, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, jfvkocmnqbrv, &zqreiqtujjyx };
static const struct jzrjinarvghn qqvpmugiynid = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 4, 0x0f, 0, buapomigirnj }, { 0, 1, 0x70, 4, zrburxphxqhf }, { 0, 5, 0xe0, 5, cnvbwytbbypn }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0xc0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, pcpjpacrwnol, NULL };
static const struct jzrjinarvghn hvcqznvscprl = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 96, {32, 32, 32, 0}, { 0, 2, 0xf0, 4, wvgqbkzvzydd }, { 0xC0, 3, 0x0f, 0, wofxanpkxiaa }, { 0x40, 4, 0x0f, 0, jfhuyfcvnpxj }, { 0, 4, 0xff, 0, nnsuhzmovrgf }, &gbquyuntkjcj, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, wfabjlbxukcl, NULL };
static const struct jzrjinarvghn uhfjezgbsofu = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x0f, 0, buapomigirnj }, { 0, 9, 0xe0, 5, cmsxvrymmhuq }, { 0, 7, 0x60, 5, ebyvbnhclkti }, { 0, 5, 0x1f, 0, nxxizblkroqr }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 9}, 7, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0} }, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn qbotksdrxqrl = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, buapomigirnj }, { 0, 5, 0x70, 4, riyympjedosd }, { 0, 4, 0x07, 0, qmemgqpfmqnj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 9}, 0, 0x03}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0} }, eaktzverivka, NULL };
static const struct jzrjinarvghn cudninqnhgjf = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 72, {72, 0, 0, 0}, { 0, 6, 0xff, 0, vswmkyynasya }, { 0, 1, 0x0F, 0, hhwccagaucle }, { 0, 1, 0xf0, 4, lrzfiwrgsash }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 9}, 7, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0} }, rltpttnrtiql, NULL };
static const struct jzrjinarvghn oszlwdaaadcw = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 1, 0x0f, 0, efnrwobuqwkq }, { 0x80, 1, 0xc0, 6, sepxqtnqesff }, { 0, 1, 0x30, 4, ebyvbnhclkti }, { 0, 4, 0x02, 1, wqmhpphavexg }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0} }, eaktzverivka, NULL };
static const struct jzrjinarvghn rksqpekqbyoe = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 128, {72, 56, 0, 0}, { 0, 6, 0xFF, 0, erafpdjoquyo }, { 0, 1, 0x0f, 0, hhwccagaucle }, { 0, 1, 0xf0, 4, wkuwmuzlxyrc }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 9}, 7, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0} }, qwrqblktyfee, NULL };
static const struct jzrjinarvghn zyktloxcjifq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 2, 0xf0, 4, buapomigirnj }, { 0x40, 3, 0x1f, 0, qdrpcjhnqjfe }, { 0x40, 4, 0xff, 0, jfhuyfcvnpxj }, { 0, 2, 0x0c, 2, flhgjwaagosb }, &ipmacjxmykvo, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 3, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0,3},3,0x10}}, eupwqyulrzyy, NULL };
static const struct jzrjinarvghn wdroysvelmxk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xff, 0, vswmkyynasya }, { 0, 2, 0x07, 0, ihjrlajmuzrx }, { 0, 2, 0x60, 5, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 9}, 1, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0} }, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn pmjbesxlbtes = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, buapomigirnj }, { 0, 6, 0x70, 4, cmsxvrymmhuq }, { 0, 6, 0x03, 0, rdeqmerohqwm }, { 0, 0, 0, 0, NULL }, &elqzgtnjohpm, {.buhyvlrkmues.oeiaiwqhculr={{0, 9}, 1, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0} }, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn bebymlgawlom = { {1, 0, 0, 1, 1, 0, 0}, 0x35, 100, {100, 0, 0, 0}, { 0, 3, 0x0F, 0, buapomigirnj }, { 0, 4, 0x07, 0, tyqkdnbinpqx }, { 0, 4, 0x70, 4, dzyoqswfyaxz }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn hdeflxmuqarj = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x0f, 0, buapomigirnj }, { 0, 9, 0xe0, 5, cmsxvrymmhuq }, { 0, 7, 0xe0, 5, ebyvbnhclkti }, { 0, 5, 0xff, 0, nxxizblkroqr }, &ifqohpdojgmw, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 7, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, hpdybfucygic, NULL };
static const struct jzrjinarvghn nnuuammvmdln = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 192, {16, 80, 16, 80}, { 1, 0, 0xf0, 4, buapomigirnj }, { 1, 0, 0x07, 0, rftgnbkwabzb }, { 1, 8, 0xf0, 4, wpbkkaqyfnoq }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 8}, 0, 0x82}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, okmjfmtereou, NULL };
#ifndef _NO_DEPRECATED
static const struct opvdfjyhetkm ndrzsrhbrnpz = {NULL, &nnuuammvmdln, 1, 95};
#endif
static const struct jzrjinarvghn wedwcvluyyuq = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 96, {16, 80, 0, 0}, { 1, 0, 0xf0, 4, buapomigirnj }, { 1, 0, 0x07, 0, rftgnbkwabzb }, { 1, 8, 0xf0, 4, wpbkkaqyfnoq }, { 0x80, 0, 0, 0, NULL },
#ifndef _NO_DEPRECATED
&myzdivzotfzc,
#else
&jhgvzparnlca,
#endif
{.buhyvlrkmues.oeiaiwqhculr = {{1, 8}, 0, 0x82}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, zrgqgsknhgmg, NULL };
static const struct jzrjinarvghn cxolyossrxql = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, plbnkrtmkrny}, { 0, 6, 0x0f, 0, bbosmglqvycs}, { 0, 8, 0x07, 0, dckrcgbseruo}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn xoubnmlsdswl = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 136, {136, 0, 0, 0}, { 0, 0x46, 0xFF, 0, pcsfqhzugqfm }, { 0x0, 5, 0xf0, 4, oioinznmyywt }, { 0, 5, 0x0f, 0, xhmffyuubxmn }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 8, 0x20}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0}, 0, 0}}, lldoojtftduj, NULL };
static const struct jzrjinarvghn dautzyxzumwh = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xf0, 4, buapomigirnj }, { 0, 3, 0x07, 0, ayuhkekjgwmt }, { 0, 2, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,8}, 2, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn raoyzhsysika = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, buapomigirnj }, { 0, 0, 0x8C, 2, wbvyayhxxweg }, { 0, 0, 0x03, 0, kzpnjyfxeljh }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,8}, 1, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, cfcakcyqnagl, NULL };
static const struct jzrjinarvghn luhpqllnqrdk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 47, {47, 0, 0, 0}, { 0, 5, 0x1F, 0, zzeskvulnbnl }, { 0, 2, 0x0C, 2, cwdypdnjdtqx }, { 0, 2, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,9}, 1, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn rehwlieguuks = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 30, {7, 8, 7, 8}, { 1, 0, 0x0F, 0, xulbipunnlsn }, { 0, 0, 0x07, 0, ejabjoghqrct }, { 0, 0, 0x70, 4, bwzkuicewiih }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,8}, 0, 0x35}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, skcllfhlpccj, NULL };
static const struct jzrjinarvghn xxhoisqdnlzy = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x0F, 0, buapomigirnj }, { 0, 1, 0x30, 4, itwesszpwkeq }, { 0, 1, 0xc0, 6, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,8}, 1, 0x0c}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn velzktpwwlna = { {1, 1, 1, 0, 0, 0, 0}, 0x32, 192, {48, 48, 48, 48}, { 0, 4, 0xf0, 4, klivdfuuohck }, { 0x00, 4, 0x0c, 2, laauizjchfid }, { 0x80, 2, 0xe0, 5, jeguxfjmlkrc }, { 2, 2, 0xff, 0, oeabmsmeenln }, &mpxkolfltkzv, {.bvyweglqjedh = (const bc7215DataVarPkt_t*)kmpfjdorsqvu}, bqiwlbylqrgm, NULL };
static const struct jzrjinarvghn vjkfkebjilwf = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 368, {64, 152, 152, 0}, { 1, 6, 0x1e, 1, buapomigirnj }, { 1, 5, 0x70, 4, thzgkhzxcbmo }, { 1, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, onbpftrvfjfv, NULL };
static const struct jzrjinarvghn chqchazhcfin = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 40, {32, 8, 0, 0}, { 0, 2, 0x0F, 0, buapomigirnj }, { 0, 1, 0x07, 0, cmsxvrymmhuq }, { 0, 1, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,3}, 1, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, aijmlnqbomlg, NULL };
static const struct jzrjinarvghn pmwdsaplucat = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96,56, 0}, { 1, 1, 0xf0, 4, buapomigirnj }, { 1, 1, 0x07, 0, ayuhkekjgwmt }, { 1, 0, 0x03, 0, ebyvbnhclkti }, { 2, 1, 0xff, 0, fldzsomvzpdo }, &zlhnhpkdjhtz, {.buhyvlrkmues.oeiaiwqhculr = {{2, 9}, 4, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bpznxebmdobd, &vqbvfgazeptr };
static const struct jzrjinarvghn maxdzzxeqadm = { {0, 0, 0, 0, 0, 1, 0}, 0x36, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, vswmkyynasya }, { 0, 1, 0x0F, 0, hhwccagaucle }, { 0, 1, 0xf0, 4, wkuwmuzlxyrc }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 7, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, rltpttnrtiql, &vruhyldxsqcg };
static const struct jzrjinarvghn ngkmzydxxlee = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 97, {96, 1, 0, 0}, { 0, 1, 0x0F, 0, buapomigirnj }, { 0, 4, 0x70, 4, aetxomkagiah }, { 0, 4, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 8}, 5, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn mcvbgkipiplb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, efnrwobuqwkq }, { 0, 0, 0x07, 0, qxpgycjvroxx }, { 0, 0, 0xf0, 4, wpbkkaqyfnoq }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, cfcakcyqnagl, NULL };
static const struct jzrjinarvghn sialocyhttlp = { {0, 0, 0, 0, 0, 1, 0}, 0x36, 140, {140, 0, 0, 0}, { 0, 16, 0xff, 0, vswmkyynasya }, { 0, 15, 0x70, 4, hhwccagaucle }, { 0, 15, 0x0f, 0, wkuwmuzlxyrc }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,3}, 14, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, xsscnakaqzvc, NULL };
static const struct jzrjinarvghn papepyqgskxe = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 5, 0xf0, 4, efnrwobuqwkq }, { 0, 4, 0x70, 4, ormmxrtoeatm }, { 0, 4, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,9}, 4, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, fqzmzhyxhonn, NULL };
static const struct jzrjinarvghn dubtokmtqggq = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {31, 31, 0, 0}, { 0, 3, 0x1e, 1, zzeskvulnbnl }, { 0, 0, 0xf0, 4, pvebvnyxmsjp }, { 0, 1, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 1, 0x20}}, ihdgkvsrxzad, NULL };
static const struct jzrjinarvghn uugdtdvjifjt = { {0, 1, 0, 1, 1, 1, 0}, 0x36, 262, {64, 64, 0, 0}, { 0, 6, 0xFF, 0, vswmkyynasya }, { 0, 1, 0x0F, 0, hhwccagaucle }, { 0, 1, 0xf0, 4, wkuwmuzlxyrc }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 7, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{1, 3}, 2, 0x04}}, prfkewqemhpr, &roohpxkzshzv };
static const struct jzrjinarvghn euczfbljmojw = { {0, 1, 0, 0, 0, 0, 0}, 0x35, 201, {35,67,67,32}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0, 0, 0x07, 0, cmsxvrymmhuq }, { 0x82, 2, 0x70, 4, vhrvrcongycf }, { 0, 0, 0x30, 4, dwqnirrjvvex }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tyjsurpbbyxy, NULL };
static const struct jzrjinarvghn kjwghvetgtpj = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 2, 0x7f, 0, afjpocuekahw }, { 0, 1, 0x70, 4, iyvncybeckuf }, { 0, 7, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.bvyweglqjedh=(const bc7215DataVarPkt_t*)zzwrunrvqvjo}, erextstztpbc, NULL };
static const struct jzrjinarvghn uvpczyuskkkn = { {0, 1, 0, 0, 0, 0, 1}, 0x34, 95, {22, 60, 8, 5}, { 1, 0, 0x1f, 0, xpqyqvwgavtb }, { 0, 2, 0x38, 3, ovaogbiheykl }, { 1, 0, 0x60, 5, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &xngvkmihdcmq, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 6, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tgposyylonet, NULL };
static const struct jzrjinarvghn yqcpkcrctrox = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 2, 0x1f, 0, xpqyqvwgavtb }, { 0, 1, 0xE0, 5, ltdgijmeizyj }, { 0, 2, 0xe0, 5, prguqramhlcb }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 3, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn dnlhjvqbvfnv = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 72, {16, 56, 0, 0}, { 1, 1, 0x0f, 0, ifrpcfykwsct }, { 1, 0, 0x07, 0, gphwgfhgpoxd }, { 1, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vxnzxedmpzzq, &bhxqyspjravl };
static const struct jzrjinarvghn fritlcgpexju = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0xF0, 4, buapomigirnj }, { 0, 6, 0x07, 0, gphwgfhgpoxd }, { 0, 6, 0x30, 4, jfhuyfcvnpxj }, { 0, 7, 0x78, 3, bicqzffsncgd }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &tqzjbbvicznq };
static const struct jzrjinarvghn gvjaoivbvlft = { {1, 1, 0, 0, 0, 0, 0}, 0x32, 256, {72, 72, 56, 56}, { 0, 5, 0xF0, 4, dvnqveurzgme }, { 0, 6, 0x07, 0, ihjrlajmuzrx }, { 0, 6, 0xe0, 5, artfgouetpom }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 6, 0x07}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, mwmcioyrqefl, NULL };
static const struct jzrjinarvghn qjesznafxjoi = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 2, 0x0f, 0, dvnqveurzgme }, { 0, 1, 0x07, 0, jhactlgtjmnm }, { 0, 1, 0x18, 3, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, jwyiiycbiibg, NULL };
static const struct jzrjinarvghn ntljcectdgxc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0x0f, 0, buapomigirnj }, { 0, 2, 0x07, 0, cmsxvrymmhuq }, { 0, 2, 0x70, 4, vhrvrcongycf }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, yuaqzxesruem, NULL };
static const struct jzrjinarvghn ashhoqgkbtrz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 3, 0x0f, 0, buapomigirnj }, { 0, 2, 0x07, 0, cmsxvrymmhuq }, { 0, 2, 0x70, 4, vhrvrcongycf }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, nnmhnxqpfemp, NULL };
static const struct jzrjinarvghn etncmnganrac = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x0f, 0, dvnqveurzgme }, { 0, 6, 0x07, 0, gwgdwghbwqvm }, { 0, 6, 0x70, 4, gdssrrauclht }, { 0, 5, 0x30, 4, nmbqpizwckfo }, &zgzeymoyuqug, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bxppsphuomwg, NULL };
static const struct jzrjinarvghn udhjhijmuhkc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x1e, 1, hkpjcpgsdhqe }, { 0, 6, 0x0f, 0, rtxamimfhtao }, { 0, 6, 0x70, 4, gdssrrauclht }, { 0, 5, 0x30, 4, nmbqpizwckfo }, &zgzeymoyuqug, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bxppsphuomwg, &iwakbkyjefuw };
static const struct jzrjinarvghn gjbxhanazzan = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x0f, 0, efnrwobuqwkq }, { 0, 6, 0x07, 0, gwgdwghbwqvm }, { 0, 6, 0x70, 4, gdssrrauclht }, { 0, 5, 0x30, 4, nmbqpizwckfo }, &mraeclcavsoh, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bxppsphuomwg, NULL };
static const struct jzrjinarvghn hukfncckyaru = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 96, {32, 32, 32, 0}, { 1, 1, 0xf0, 4, dvnqveurzgme }, { 1, 1, 0x07, 0, gwgdwghbwqvm }, { 1, 2, 0x70, 4, vhrvrcongycf }, { 1, 3, 0x03, 0, nmbqpizwckfo }, &hjvfjrpmdwha, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, rcrfmcefxnvr, NULL };
static const struct jzrjinarvghn reznbthidfio = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 1, 0xF0, 4, kvsuhbwaysqo }, { 0, 0, 0xe0, 5, ctuxflcwkaxi }, { 0, 0, 0x0c, 2, zitybsxpqiom }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0,8}, 0, 0x00}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, eaktzverivka, NULL };
static const struct jzrjinarvghn bzeafqixpbgp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 5, 0x0f, 0, buapomigirnj }, { 0, 3, 0x0e, 1, mxvavncfceat }, { 0, 6, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 3, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn mqkgugnpfqmu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, vudrgutquhxw }, { 0, 6, 0x0f, 0, xsobwwhnqyha }, { 0, 8, 0x07, 0, dckrcgbseruo }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, aijmlnqbomlg, NULL };
static const struct jzrjinarvghn ndbjtpwplnsj = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, vswmkyynasya }, { 0, 6, 0x0f, 0, xsobwwhnqyha }, { 0, 8, 0x07, 0, dckrcgbseruo }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn cpthvncrpezz = { {0, 1, 0, 0, 0, 1, 0}, 0x30, 64, {32, 32, 0, 0}, { 0, 0, 0x0f, 0, efnrwobuqwkq }, { 0, 2, 0x07, 0, slharvisybgt }, { 0, 0, 0xf0, 4, lrzfiwrgsash }, { 0, 0, 0, 0, NULL }, &cqvmenntifmu, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vcrustzgkdel, NULL };
static const struct jzrjinarvghn rbplxipbfxrn = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 2, 0xf0, 4, efnrwobuqwkq }, { 0, 3, 0x07, 0, ojjpsncigjxf }, { 0, 3, 0x70, 4, rlohtdspsezy }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 8}, 2, 0xb8}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, zrcrmamyqgft, NULL };
static const struct jzrjinarvghn qthyjxpnacge = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 5, 0x0f, 0, buapomigirnj }, { 0, 2, 0xe0, 5, cmsxvrymmhuq }, { 0, 5, 0x60, 5, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bmzkvmhqnjyb, NULL };
static const struct jzrjinarvghn mjoudrvtifda = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 312, {160, 152, 0, 0}, { 1, 6, 0xfe, 1, ztllrbdaneil }, { 1, 5, 0x70, 4, thzgkhzxcbmo }, { 1, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL }, &qgykejxdlosa, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 6, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{1, 9}, 5, 0x01}}, jgsneyvxdfad, &urxsveyojyse };
static const struct jzrjinarvghn eivcuwkmjmyy = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 160, {56, 104, 0, 0}, { 1, 9, 0x3E, 1, kgdzjljuqqgi }, { 1, 5, 0x70, 4, qygwxvpkgfvt }, { 1, 10, 0x0f, 0, jawjcodvnury }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vxnzxedmpzzq, NULL };
static const struct jzrjinarvghn ffgmyumzqqbo = { {0, 1, 0, 0, 0, 0, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, efnrwobuqwkq }, { 0x00, 2, 0x07, 0, jwzveoevzgyv }, { 0, 0, 0xf0, 4, lznqwjxyjfkm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, nxoifrxfomfj, NULL };
static const struct jzrjinarvghn fdfqwxqedzfk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0xff, 0, umnuuvrdsjhx }, { 0x00, 0, 0x07, 0, cmsxvrymmhuq }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &wtvxxcpnyuur, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn xkgqlyhqnrkb = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 72, {72, 0, 0, 0}, { 0, 6, 0xff, 0, erafpdjoquyo }, { 0, 1, 0x0F, 0, hhwccagaucle }, { 0, 1, 0xf0, 4, wkuwmuzlxyrc }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 9}, 7, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0} }, rltpttnrtiql, NULL };
static const struct jzrjinarvghn tqmesnejmjio = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x1f, 0, xpqyqvwgavtb }, { 0x80, 3, 0x30, 4, uulmcnvnkhop }, { 0, 3, 0x03, 0, gsqfyunwsqrs }, { 0, 2, 0xff, 0, ylcxmfskptwm }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)syyzdovmflnp }, erextstztpbc, NULL };
static const struct jzrjinarvghn avmsygiqppuf = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 1, 0x1f, 0, xpqyqvwgavtb }, { 0x80, 3, 0x30, 4, uulmcnvnkhop }, { 0, 3, 0x03, 0, gsqfyunwsqrs }, { 0, 2, 0xff, 0, yrgmxhydaqhd }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)sjxdtrttjqul }, erextstztpbc, NULL };
static const struct jzrjinarvghn rqaaemputfsz = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 4, 0x0f, 0, snifltmhdyyp }, { 0, 4, 0x30, 4, mtmsqrrolvof }, { 0, 2, 0x07, 0, ezynxglgampz }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 9}, 4, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn zjrcitgyiyvg = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0x0f, 0, zzeskvulnbnl }, { 0, 4, 0x18, 3, ythihyyccokz }, { 0, 4, 0x07, 0, rrfxmspaphxa }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 3}, 4, 0x20}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn nutgrilanbjx = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0xf0, 4, zzeskvulnbnl }, { 0, 2, 0x07, 0, pbacsnxpcpud }, { 0, 0, 0x18, 3, vubnovfywcwm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn rsgubciiffcf = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0xf0, 4, zzeskvulnbnl }, { 0, 2, 0x03, 0, ythihyyccokz }, { 0, 0, 0x18, 3, vubnovfywcwm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr={{0, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn pmqswaualwhp = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 4, 0xf0, 4, zzeskvulnbnl }, { 0x0, 4, 0x07, 0, iubiooqdloyk }, { 0, 2, 0x70, 4, rrfxmspaphxa }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0,3},4,0x08}}, slomxntxjsam, NULL };
static const struct jzrjinarvghn ibjkosbbufbq = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, dvnqveurzgme }, { 0x0, 2, 0x70, 4, vxfmuobwaakd }, { 0, 1, 0x70, 4, gorgucnynypd }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, scxswegaqvtf, NULL };
static const struct jzrjinarvghn kcaxehdponvp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 152, {152, 0, 0, 0}, { 0, 6, 0x3e, 1, xpqyqvwgavtb }, { 0x80, 5, 0xe0, 5, ejabjoghqrct }, { 0, 5, 0x0c, 2, gsqfyunwsqrs }, { 0, 6, 0x80, 7, wqmhpphavexg }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 9}, 8, 0x20}}, pehmuunkplcs, &pweyualfgbur };
static const struct jzrjinarvghn wkabhnqlzujr = { {0, 1, 1, 0, 0, 0, 0}, 0x37, 113, {12, 45, 12, 44}, { 3, 3, 0x0f, 0, buapomigirnj }, { 3, 4, 0x07, 0, cmsxvrymmhuq }, { 3, 3, 0xe0, 5, gehvvnkxjrrg }, { 0, 0, 0, 0, NULL }, &yynjrgvifofa, {.bvyweglqjedh = (bc7215DataVarPkt_t*)qzlestjjkptx}, zlekbqquctli, NULL };
static const struct jzrjinarvghn kncnqxewqlze = { {1, 1, 1, 0 , 0, 0, 0}, 0x36, 160, {80, 80, 0, 0}, { 0, 5, 0xf0, 4, dvnqveurzgme}, { 0, 6, 0x07, 0, ihjrlajmuzrx}, { 0, 6, 0xC0, 6, jdapwvpazjzv }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)mfsnqiyfomas}, hjantykpakiw, NULL };
static const struct jzrjinarvghn bhkloqyxpyxq = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 3, 0x0f, 0, buapomigirnj }, { 0, 1, 0x0f, 0, qmzixmqfdnmw }, { 0, 1, 0xe0, 5, monjdaygiswc }, { 0, 6, 0x1f, 0, ciaaebaazygi }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn orwgusyyouri = { {0, 1, 1, 0, 0, 0, 0}, 0x32, 192, {96, 48, 48, 0}, { 1, 4, 0x0f, 0, snifltmhdyyp }, { 1, 4, 0x30, 4, mtmsqrrolvof }, { 1, 2, 0x07, 0, ezynxglgampz }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.bvyweglqjedh = (const bc7215DataVarPkt_t*)udfkhxapkpoi}, odkkmzjhafwq, NULL };
static const struct jzrjinarvghn cqduocvilsiv = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 161, {56, 104, 1, 0}, { 1, 9, 0xFE, 1, hkpjcpgsdhqe }, { 1, 5, 0x70, 4, qygwxvpkgfvt }, { 1, 10, 0x0f, 0, jawjcodvnury }, { 0, 0, 0, 0, NULL}, &xgllypiasniq, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vxnzxedmpzzq, NULL };
static const struct jzrjinarvghn jhmimsougmax = { {1, 0, 0, 0, 0, 0, 0}, 0x36, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, buapomigirnj }, { 0x0, 5, 0x70, 4, rdeqmerohqwm }, { 0, 4, 0x07, 0, flvavtvltprq }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x03}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, eaktzverivka, NULL };
static const struct jzrjinarvghn xrxeqoncgzhw = { {1, 0, 0, 0, 0, 0, 0}, 0x36, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, buapomigirnj }, { 0x40, 5, 0xf0, 4, dnrvuxesocaa }, { 0, 5, 0xf0, 4, srkmwlghtzdt }, { 0, 0, 0, 0, NULL }, &krhvlwzzqgbe, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x03}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 0, 0x80}}, eaktzverivka, NULL };
static const struct jzrjinarvghn smwbdffluovl = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, buapomigirnj }, { 0x40, 5, 0xf0, 4, dnrvuxesocaa }, { 0, 5, 0xf0, 4, srkmwlghtzdt }, { 0, 0, 0, 0, NULL }, &krhvlwzzqgbe, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x03}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 0, 0x80}}, eaktzverivka, NULL };
#ifndef _NO_DEPRECATED
static const struct opvdfjyhetkm urhvwvrbxzdd = {NULL, &mvjacrgmcqrk, 2, 165};
static const struct jzrjinarvghn ijnzxwmmbvrz = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0xf0, 4, myxgzexwujuf }, { 0x00, 1, 0x0c, 2, fbxwaojofjhk }, { 0, 1, 0x03, 0, kzpnjyfxeljh }, { 0x80, 2, 0xf0, 4, eeighxiyxies }, &uckbcozwnjsc, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,9},0,0x08}}, bdyhkgjgowgw, NULL };
static const struct opvdfjyhetkm uoexdvqutnft = {NULL, &erzqxjwqllkw, 2, 165};
static const struct jzrjinarvghn uuzvdmcjgkeb = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0xf0, 4, zzeskvulnbnl }, { 0x00, 1, 0x0c, 2, fbxwaojofjhk }, { 0, 1, 0x03, 0, kzpnjyfxeljh }, { 0x80, 2, 0xf0, 4, wxaiwoaahkwe }, &nrdxswsbteli, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,9},0,0x10}}, bdyhkgjgowgw, NULL };
static const struct opvdfjyhetkm mnshgudisetv = {NULL, &kmsilceuotxy, 2, 165};
static const struct jzrjinarvghn ebfejqvupbin = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0xf0, 4, zzeskvulnbnl }, { 0x00, 1, 0x0c, 2, fbxwaojofjhk }, { 0, 1, 0x03, 0, kzpnjyfxeljh }, { 0x80, 2, 0xf0, 4, eeighxiyxies }, &bgmbhviuwehp, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,9},0,0x08}}, bdyhkgjgowgw, NULL };
static const struct opvdfjyhetkm pxhubafgllji = {NULL, &rvzizqwfxphi, 2, 165};
static const struct jzrjinarvghn tvoromxodhvl = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0xf0, 4, dvnqveurzgme }, { 0x00, 1, 0x0c, 2, fbxwaojofjhk }, { 0, 1, 0x03, 0, kzpnjyfxeljh }, { 0x80, 2, 0xf0, 4, wxaiwoaahkwe }, &gmpslrmizinl, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,9},0,0x10}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn etdigqhbjjsq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, qeojruvmiqhg }, { 0xc0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, akblvvhzssfj, NULL };
static const struct jzrjinarvghn aoanqczuvzgi = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, izahqyxwrzzp }, { 0xc0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, ovjvngnmawde, NULL };
#endif
static const struct jzrjinarvghn heahpeopqgwb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x0f, 0, buapomigirnj }, { 0, 1, 0xF0, 4, tktdvolstckk }, { 0, 1, 0x0F, 0, lrzfiwrgsash }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0X80}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn zialejqfzsio = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 2, 0xf0, 4, zzeskvulnbnl }, { 1, 2, 0x07, 0, iubiooqdloyk }, { 1, 4, 0xe0, 5, hnvfgxbuownj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 3}, 2, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, rfqbmelawvsm, NULL };
static const struct jzrjinarvghn duvdqmzcsqak = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, wvgqbkzvzydd }, { 0, 0, 0x07, 0, cmsxvrymmhuq}, { 0, 0, 0x30, 4, jfhuyfcvnpxj}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn ztatpjfibwlx = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, efnrwobuqwkq }, { 0, 0, 0x07, 0, cmsxvrymmhuq}, { 0, 0, 0x30, 4, jfhuyfcvnpxj}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn weujghnvyndw = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 144, {16, 56, 16, 56}, { 1, 3, 0xf0, 4, buapomigirnj }, { 1, 0, 0xF0, 4, jthdjmscwilf }, { 1, 1, 0x30, 4, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0Xf0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, riqfffioqmin, NULL };
static const struct jzrjinarvghn ybluiyzkisqk = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 160, {16, 64, 16, 64}, { 1, 3, 0xf0, 4, buapomigirnj }, { 1, 0, 0xF0, 4, jthdjmscwilf }, { 1, 1, 0x30, 4, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0Xf0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, riqfffioqmin, NULL };
static const struct jzrjinarvghn alaekjxpzbkd = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 48, {24, 24, 0, 0}, { 0, 2, 0x0f, 0, wvgqbkzvzydd }, { 0, 2, 0x70, 4, vxfmuobwaakd }, { 0, 1, 0x70, 4, dzyoqswfyaxz }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 8}, 2, 0xa7}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, scxswegaqvtf, NULL };
static const struct jzrjinarvghn trxqzlbnsqnp = { {0, 1, 0, 0, 0, 1, 0}, 0x21, 102, {34, 34, 34, 0}, { 0, 1, 0x1E, 1, efnrwobuqwkq }, { 0, 0, 0x70, 4, jwfwescyfyuh }, { 0, 0, 0x0c, 2, vubnovfywcwm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 8}, 0, 0x9c}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, zjpdowvsbula, NULL };
static const struct jzrjinarvghn qhcxpgvmajbc = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 100, {50, 50, 0, 0}, { 0, 3, 0x78, 3, zzeskvulnbnl }, { 0x80, 0, 0x0c, 2, aebsjwjbaiod }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 4, 0xff, 0, buadosfwgfaj }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 9}, 5, 0x30}}, ihdgkvsrxzad, NULL };
static const struct jzrjinarvghn ukpsalkgowar = { {0, 0, 0, 0, 0, 1, 0}, 0x30, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, vswmkyynasya }, { 0, 1, 0x0F, 0, hhwccagaucle }, { 0, 1, 0xf0, 4, wkuwmuzlxyrc }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 7, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, rltpttnrtiql, &vruhyldxsqcg };
static const struct jzrjinarvghn vgozoionavgd = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, vudrgutquhxw}, { 0, 6, 0x0f, 0, xsobwwhnqyha}, { 0, 8, 0x07, 0, qzxxuykbuavx }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn xrhpswddthgh = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 17, {16, 1, 0, 0}, { 0, 1, 0xF8, 3, nixsfpbeofss }, { 0, 1, 0x07, 0, cmsxvrymmhuq }, { 0, 0, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 0, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, upuorsdduhef, NULL };
static const struct jzrjinarvghn fspygxzwnkkz = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 5, 0x0f, 0, efnrwobuqwkq }, { 0, 4, 0x70, 4, cmsxvrymmhuq }, { 0, 4, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 3, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, qoirfytyezgn, NULL };
static const struct jzrjinarvghn mooqezgtowrx = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 2, 0xf0, 4, wvgqbkzvzydd }, { 0, 3, 0x07, 0, mxvavncfceat }, { 0, 3, 0x70, 4, rlohtdspsezy }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, iyfkzmrxyuxz, NULL };
static const struct jzrjinarvghn ceoalankzpjd = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, buapomigirnj}, { 0, 0, 0x07, 0, cmsxvrymmhuq}, { 0, 3, 0x03, 0, jfhuyfcvnpxj}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn mpoipupheqbm = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 176, {112, 64, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0, 7, 0xe0, 5, qttzvwrerooe }, { 0, 5, 0xe0, 5, wmyxfyxnffbi }, { 0, 12, 0x07, 0, qzwhrrwdagpl }, &fyjtzzptjzpp, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, jgsneyvxdfad, NULL };
static const struct jzrjinarvghn wfznitbkmzgy = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 56, {8, 48, 0, 0}, { 1, 2, 0x0f, 0, buapomigirnj }, { 1, 0, 0x0f, 0, mxxtrfhnirvy }, { 1, 1, 0x07, 0, xbpmeyfhhdfd }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, xhzoapezwhhv, NULL };
static const struct jzrjinarvghn yjbanrpjklab = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 56, {8, 48, 0, 0}, { 1, 2, 0x7E, 1, igcregcudtsx }, { 1, 0, 0x0f, 0, mxxtrfhnirvy }, { 1, 1, 0x07, 0, xbpmeyfhhdfd }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, xhzoapezwhhv, &hrvimfxzossz };
static const struct jzrjinarvghn yiexfzyuakpb = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, ifrpcfykwsct }, { 1, 1, 0x07, 0, ayuhkekjgwmt }, { 1, 0, 0x03, 0, ebyvbnhclkti }, { 2, 1, 0xff, 0, hosnmkalbjvc }, &rykgwspogprv, {.buhyvlrkmues.oeiaiwqhculr = {{2, 9}, 4, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bpznxebmdobd, &qessrelebsqo };
static const struct jzrjinarvghn jemgcilepxyr = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, buapomigirnj }, { 0x0, 5, 0x70, 4, rdeqmerohqwm }, { 0, 4, 0x07, 0, dzyoqswfyaxz }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, eaktzverivka, NULL };
static const struct jzrjinarvghn vstqeiwmioor = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfe, 1, ztllrbdaneil }, { 3, 5, 0x70, 4, thzgkhzxcbmo }, { 3, 8, 0xf0, 4, okpvknxqpcxx }, { 0, 0, 0, 0, NULL }, &xgllypiasniq, {.buhyvlrkmues.oeiaiwqhculr = {{3, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{3, 9}, 9, 0x0f}}, jfvkocmnqbrv, &tfkrysxuwiqn };
static const struct jzrjinarvghn oqfdddifvzle = { {0, 1, 0, 0 ,0, 0, 0}, 0x36, 216, {64, 152, 0, 0}, { 1, 6, 0xff, 0, onzuomwywyrc }, { 1, 5, 0x70, 4, qygwxvpkgfvt }, { 1, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL}, &nppopsfvalpj, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, jgsneyvxdfad, NULL };
static const struct jzrjinarvghn xkkhmbnwdgvp = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 317, {5, 160, 152, 0}, { 2, 6, 0xfe, 1, ztllrbdaneil }, { 2, 5, 0x70, 4, thzgkhzxcbmo }, { 2, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL }, &euzeynhxvmvh, {.buhyvlrkmues.oeiaiwqhculr = {{2, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{1, 3}, 12, 0x80}}, yzbsxjngujtn, NULL };
static const struct jzrjinarvghn agtbopkraeot = { {0, 1, 0, 0, 0, 1, 0}, 0x30, 128, {64, 64, 0, 0}, { 0, 6, 0xff, 0, vswmkyynasya }, { 0, 1, 0x0f, 0, hhwccagaucle }, { 0, 1, 0xf0, 4, wkuwmuzlxyrc }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 7, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, rltpttnrtiql, &vruhyldxsqcg };
static const struct jzrjinarvghn dalzafbsdwwq = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 424, {24, 400, 0, 0}, { 1, 10, 0x3c, 2, buapomigirnj }, { 1, 22, 0x07, 0, ebpakvtdyfdu }, { 1, 22, 0x70, 4, wvvnysigoaye }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 24, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, rfqbmelawvsm, NULL };
static const struct jzrjinarvghn mjqlajgqjenq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0xff, 0, vswmkyynasya }, { 0, 0, 0x07, 0, lxuqcjfntbsi }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0x80, 0, 0, 0, NULL },
#ifndef _NO_DEPRECATED
&umudfdkvwjjd,
#else
&jhgvzparnlca,
#endif
{.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0,8},1,0x16}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn jfqbhwpmtjrb = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 64, {20, 44, 0, 0}, { 1, 0, 0xf0, 4, buapomigirnj }, { 1, 0, 0x03, 0, edsbvmthdhbe }, { 1, 0, 0x0c, 2, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 2, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tzmbteavenkv, NULL };
static const struct jzrjinarvghn bfpblayggzfp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x0f, 0, dvnqveurzgme }, { 0, 2, 0x0e, 1, qxpgycjvroxx }, { 0, 1, 0x60, 5, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &yiencdduerag, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn oortzxaheers = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 192, {32, 160, 0, 0}, { 1, 6, 0x1e, 1, buapomigirnj }, { 1, 4, 0x07, 0, sxiasvpqtlhk }, { 1, 8, 0x07, 0, eqdjldrmitax }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 2, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, rfqbmelawvsm, NULL };
static const struct jzrjinarvghn iajpndojcexc = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 80, {80, 0, 0, 0}, { 0, 3, 0x0f, 0, buapomigirnj }, { 0, 1, 0x0f, 0, qmzixmqfdnmw }, { 0, 1, 0xe0, 5, monjdaygiswc }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, aijmlnqbomlg, NULL };
static const struct jzrjinarvghn nuivbdiarbvb = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 56, {56, 0, 0, 0}, { 0, 2, 0x1f, 0, sowntkssmkug }, { 0, 1, 0x03, 0, ysfpkhpowxhl }, { 0, 1, 0x38, 3, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &lnvxvcmwwqfo };
static const struct jzrjinarvghn txpmqgvaddpm = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 120, {56, 64, 0, 0}, { 1, 1, 0xF0, 4, buapomigirnj }, { 1, 2, 0x07, 0, cmsxvrymmhuq }, { 1, 3, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)jipcobyqakur}, xhzoapezwhhv, NULL };
static const struct jzrjinarvghn tiflxuaxfahj = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 56, {12, 44, 0, 0}, { 1, 3, 0x0f, 0, buapomigirnj }, { 1, 4, 0x07, 0, cmsxvrymmhuq }, { 1, 3, 0xe0, 5, gehvvnkxjrrg }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x03}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, mnmuaepxbiut, NULL };
static const struct jzrjinarvghn qeneswuwzfix = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 140, {140, 0, 0, 0}, { 0, 16, 0xFF, 0, vswmkyynasya }, { 0, 15, 0xf0, 4, hhwccagaucle }, { 0, 15, 0x0f, 0, wkuwmuzlxyrc }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 14, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, xsscnakaqzvc, NULL };
static const struct jzrjinarvghn itvfwtfiwhgo = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 128, {112, 16, 0, 0}, { 0, 3, 0x3C, 2, buapomigirnj }, { 0x80, 2, 0x0e, 1, aetxomkagiah }, { 0, 2, 0x70, 4, xaiaynoychft }, { 0, 3, 0x02, 1, ncnatfptafnx }, &ucyclyhzfvad, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn wicwaspfhaet = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 64, {48, 16, 0, 0}, { 0, 1, 0x0f, 0, efnrwobuqwkq }, { 0, 1, 0xc0, 6, sepxqtnqesff }, { 0x80, 1, 0x30, 4, ebyvbnhclkti }, { 1, 0, 0x07, 0, tjluoiuorjru }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, rlkwfmxievhz, NULL };
static const struct jzrjinarvghn rsoscflyxtpd = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 46, {46, 0, 0, 0}, { 0, 3, 0x0f, 0, buapomigirnj }, { 0, 1, 0x07, 0, xdcmwtnyzghg }, { 0, 2, 0x70, 4, vhrvrcongycf }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x38}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, zjckkaxrhoow, NULL };
static const struct jzrjinarvghn zezpyzgzlpwh = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1f, 0, xpqyqvwgavtb }, { 0, 4, 0x1f, 2, vysaxkgccxqs }, { 0, 4, 0x03, 0, gsqfyunwsqrs }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 5, 0x40}}, erextstztpbc, NULL };
static const struct jzrjinarvghn chlcfvsitqam = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1f, 0, xpqyqvwgavtb }, { 0, 4, 0x70, 4, bfbhdqtabiyo }, { 0, 4, 0x03, 0, gsqfyunwsqrs }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 3}, 5, 0x40}}, erextstztpbc, NULL };
static const struct jzrjinarvghn yomytksmgafd = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x0f, 0, efnrwobuqwkq }, { 0, 5, 0xe0, 5, cmsxvrymmhuq }, { 0, 7, 0x60, 5, ebyvbnhclkti }, { 0, 1, 0xf0, 4, atgvcvrcabbv }, &yiencdduerag, {.buhyvlrkmues.oeiaiwqhculr={{0, 9}, 3, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0} }, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn ifvfppnsregz = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, efnrwobuqwkq }, { 0, 1, 0x07, 0, okmydbbbrxta }, { 0, 2, 0x07, 0, eqdjldrmitax }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0xc0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0}, 0, 0}}, urjoiowewbrz, NULL };
static const struct jzrjinarvghn kqryzismnwvq = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {23, 8, 23, 8}, { 1, 0, 0x78, 3, buapomigirnj }, { 0, 0, 0x38, 3, cmsxvrymmhuq }, { 1, 0, 0x07, 0, ptyajwmvabif }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0}, 0, 0}}, skcllfhlpccj, NULL };
static const struct jzrjinarvghn zbbbqfxxafxa = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {25, 6, 25, 6}, { 1, 0, 0x0f, 0, vudrgutquhxw }, { 0, 0, 0xe0, 5, ojjpsncigjxf }, { 0, 1, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0}, 0, 0}}, skcllfhlpccj, NULL };
static const struct jzrjinarvghn pdrkucllfctr = { {0, 1, 0, 0, 0, 0, 0}, 0x3C, 85, {76, 9, 0, 0}, { 0, 2, 0xFF, 0, vswmkyynasya }, { 0, 0, 0x70, 4, pauwnwnymqfx }, { 0, 1, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 1}, 0, 0x0F}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0}, 0, 0}}, slupaugvfdqp, NULL };
static const struct jzrjinarvghn qfencfwqaemo = { {0, 1, 0, 0, 0, 1, 0}, 0x36, 86, {43, 43, 0, 0}, { 0, 2, 0xf0, 4, zzeskvulnbnl }, { 0x80, 0, 0x0c, 2, aebsjwjbaiod }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 4, 0x30, 4, iqzjspedmtls }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 0, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, ihdgkvsrxzad, NULL };
static const struct jzrjinarvghn vhoqsybwxvii = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 10, 0x7c, 2, efnrwobuqwkq }, { 0, 6, 0xe0, 5, qttzvwrerooe}, { 0, 4, 0xe0, 5, wmyxfyxnffbi}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 9, 0x20}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &ztygsngezhpe };
static const struct jzrjinarvghn iygzwypjstpx = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 2, 0x1e, 1, ifrpcfykwsct }, { 0, 1, 0x07, 0, jhactlgtjmnm }, { 0, 1, 0x38, 3, zbqvaxnspqgl }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, jwyiiycbiibg, &wowglohcaqts };
static const struct jzrjinarvghn betiwafeckrb = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x1e, 1, zzeskvulnbnl }, { 0x0, 8, 0xe0, 5, iubiooqdloyk }, { 0, 6, 0x70, 4, rrfxmspaphxa }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 6, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, slomxntxjsam, &dmhcbxpokfvl };
static const struct jzrjinarvghn vkbsixoeqrku = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x7e, 1, mvnmnugqwdob }, { 0x0, 6, 0x0f, 0, pfiogbnjfeir }, { 0, 8, 0x07, 0, ptyajwmvabif }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &llkecvtexmfo };
static const struct jzrjinarvghn uzgimvnlvmox = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 33, {1, 32, 0, 0}, { 1, 0, 0x1e, 1, dvnqveurzgme }, { 1, 1, 0xe0, 5, qxpgycjvroxx }, { 1, 0, 0x60, 5, kzpnjyfxeljh }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, djyrdlmsgmez, &frscosiyzwec };
static const struct jzrjinarvghn tcvkzlbmgnxz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x1e, 1, myxgzexwujuf }, { 0x80, 6, 0x07, 0, cwdypdnjdtqx }, { 0, 8, 0x07, 0, dckrcgbseruo }, { 0, 8, 0xc0, 6, zjrtsbxvzxsn }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &qopbamnhnoyi };
static const struct jzrjinarvghn mouajiapoqgd = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 108, {36, 36, 36, 0}, { 0, 2, 0xf0, 4, dvnqveurzgme }, { 0, 3, 0x0c, 2, ythihyyccokz }, { 0, 3, 0x03, 0, lrzfiwrgsash }, { 0, 2, 0x0c, 2, rxpjkrrfamcy }, &aaigbdzuflwz, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, zjpdowvsbula, &vuflkqglkjvn };
static const struct jzrjinarvghn rjcujhmjcxlp = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x1e, 1, dvnqveurzgme }, { 0x0, 9, 0xe0, 5, cmsxvrymmhuq }, { 0, 7, 0x60, 5, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 7, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &xldkipqymodw };
static const struct jzrjinarvghn fsybkwuxtyus = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {56, 120, 0, 0}, { 1, 10, 0x7e, 1, mvnmnugqwdob }, { 0x81, 7, 0x70, 4, cgaowyvjwkxn }, { 1, 11, 0x70, 4, vhrvrcongycf }, { 1, 5, 0xF0, 4, rmihcqimeubi }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 7, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, jgsneyvxdfad, &ttlrdkkqembi };
static const struct jzrjinarvghn avkknyarswma = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x1e, 1, inyvfdvqynog }, { 0, 2, 0x06, 1, cjitotwwwapg }, { 0, 1, 0xc0, 6, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, bdyhkgjgowgw, &vwtsrtlryarn };
static const struct jzrjinarvghn yjtddijhglgg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x7e, 1, mvnmnugqwdob }, { 0, 1, 0xf0, 4, tktdvolstckk }, { 0, 1, 0x0F, 0, lrzfiwrgsash }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, bdyhkgjgowgw, &bqaywwuvjouw };
static const struct jzrjinarvghn watfrrskgzna = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 9, 0x0f, 0, buapomigirnj }, { 0, 6, 0x7f, 0, pasclnhfqzbk }, { 0, 7, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, tvxxnczaflhd, &mdpyyvdwvhhn };
static const struct jzrjinarvghn vvfybqkrhfxk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 0, 0x1e, 1, pvvpzdjqjogi }, { 0x80, 1, 0x03, 0, mhguofhwxuno }, { 0, 1, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0x60, 5, ythihyyccokz }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, tvxxnczaflhd, &asjfjvuovcnb };
static const struct jzrjinarvghn ybppuoltxsxa = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 2, 0x1e, 1, buapomigirnj }, { 0, 1, 0x70, 4, iyvncybeckuf }, { 0, 7, 0x03, 0, pregfugqsspv }, { 0, 1, 0x0c, 2, fvleykqpohms }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 0}, 0, 0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, bdyhkgjgowgw, &vhfuftsiaaoo };
static const struct jzrjinarvghn dlxxrrjgsjcp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 1, 0x7e, 1, igcregcudtsx }, { 0, 0, 0x70, 4, dphnzbdprfav }, { 0, 0, 0x07, 0, ezynxglgampz }, { 0, 5, 0x70, 4, zngtxtrxsnjv }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0x09}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, tvxxnczaflhd, &dkoueixsmplc };
static const struct jzrjinarvghn tmhccfnvhlnc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 2, 0x7e, 1, mvnmnugqwdob }, { 0, 1, 0x70, 4, dphnzbdprfav }, { 0, 1, 0x07, 0, zbqvaxnspqgl }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, erextstztpbc, &wowglohcaqts };
static const struct jzrjinarvghn tdrgyunqmehi = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xf8, 3, kgdzjljuqqgi }, { 1, 2, 0x07, 0, cmsxvrymmhuq }, { 1, 3, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.bvyweglqjedh = (bc7215DataVarPkt_t*)ffcerrqtjhps}, xhzoapezwhhv, &lynbapkwggrg };
static const struct jzrjinarvghn pzmbktgjwzqy = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 68, {68, 0, 0, 0}, { 0, 1, 0x0e, 1, sguttdsgjuwf }, { 0, 0, 0x07, 0, cmsxvrymmhuq }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, bdyhkgjgowgw, &pkyxcmuxqund };
static const struct jzrjinarvghn sihswuahetxi = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 7, 0xe0, 5, qttzvwrerooe }, { 0, 5, 0xe0, 5, wmyxfyxnffbi }, { 0, 12, 0x07, 0, qzwhrrwdagpl }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &uwqtblpoevgw };
static const struct jzrjinarvghn jglfryytmykj = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 1, 0xf0, 4, buapomigirnj }, { 0x0, 6, 0x07, 0, cmsxvrymmhuq }, { 0, 6, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x02}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &tqzjbbvicznq };
static const struct jzrjinarvghn bscwnkwnrqst = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, buapomigirnj }, { 1, 1, 0x07, 0, ayuhkekjgwmt }, { 1, 0, 0x03, 0, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{2, 9}, 4, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bpznxebmdobd, &mmkjpqjnjino };
static const struct jzrjinarvghn gkedycgrikvv = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, zctsiebmasxs }, { 0, 1, 0x07, 0, okmydbbbrxta }, { 0, 2, 0x07, 0, eqdjldrmitax }, { 0, 1, 0x08, 3, jubunxyeqbqy }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0xc0}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, rltpttnrtiql, &vruhyldxsqcg };
static const struct jzrjinarvghn arkeynlsaake = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {40, 136, 0, 0}, { 1, 5, 0x1E, 1, buapomigirnj }, { 1, 6, 0x07, 0, ysfpkhpowxhl }, { 1, 7, 0x0E, 1, yxxvnrvpchdh }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x40}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vxnzxedmpzzq, &gsmtwvkdbwhi };
static const struct jzrjinarvghn xxrzflzknzns = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 168, {12, 44, 68, 44}, { 3, 3, 0x0f, 0, buapomigirnj }, { 3, 4, 0x07, 0, cmsxvrymmhuq }, { 3, 3, 0xe0, 5, gehvvnkxjrrg }, { 0, 0, 0, 0, NULL }, &yynjrgvifofa, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x03}, .buhyvlrkmues.cuoycwtsmtjr = {{3, 9}, 5, 0x03}}, ykquefjrepxc, &xisdkgnxkbvl };
static const struct jzrjinarvghn vaiktfbqltsi = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 170, {12, 44, 70, 44}, { 3, 3, 0x1e, 1, buapomigirnj }, { 3, 4, 0x07, 0, cmsxvrymmhuq }, { 3, 3, 0xe0, 5, gehvvnkxjrrg }, { 0, 0, 0, 0, NULL }, &yynjrgvifofa, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 5, 0x03}, .buhyvlrkmues.cuoycwtsmtjr = {{3, 9}, 5, 0x03}}, ykquefjrepxc, &zvpcsdldazbs };
static const struct jzrjinarvghn cxmhfrvnxafa = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 48, {40, 8, 0, 0}, { 0x80, 3, 0x0e, 1, vadisvozkypl }, { 0, 2, 0x07, 0, tfndsdmrabjz }, { 0, 2, 0x60, 5, vubnovfywcwm }, { 1, 0, 0x0f, 0, ahopevbbiawg }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0x10}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, awvsbtnwqzll, &fgufysedrnrp };
static const struct jzrjinarvghn ljxbngcbojsa = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 72, {8, 64, 0, 0}, { 1, 3, 0x7e, 1, mvnmnugqwdob }, { 1, 1, 0x07, 0, cmsxvrymmhuq }, { 1, 1, 0x70, 4, mipwiqvjrowq }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, vxnzxedmpzzq, &rhrzyxbcjdnw };
static const struct jzrjinarvghn oxoygbdmyemz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 13, 0x1e, 1, myxgzexwujuf }, { 0, 6, 0x0f, 0, xsobwwhnqyha }, { 0, 8, 0x07, 0, dckrcgbseruo }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 5, 0x04}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &taunhhzbwyum };
static const struct jzrjinarvghn catiaveohgfk = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 0, 0x1e, 1, buapomigirnj }, { 0, 1, 0xf0, 4, qvrrscqebffk }, { 0, 0, 0x60, 5, kzpnjyfxeljh }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, pcpjpacrwnol, &aayripgropxj };
static const struct jzrjinarvghn bxmahmbdzgeg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1e, 1, ifrpcfykwsct }, { 0, 2, 0x0e, 1, qxpgycjvroxx }, { 0, 1, 0x60, 5, ebyvbnhclkti }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 2, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, &hhffogqwcnju };
static const struct jzrjinarvghn xuwpsxrewyix = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x1e, 1, ifrpcfykwsct }, { 0, 1, 0xc0, 6, ehzpjufnzfaz }, { 0, 1, 0x3f, 0, gdbpuqhiqmnj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 8}, 2, 0x32}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, &lasyhjtdiovp };
static const struct jzrjinarvghn odijkqudwvrd = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, buapomigirnj }, { 0, 1, 0x07, 0, okmydbbbrxta }, { 0, 2, 0x07, 0, eqdjldrmitax }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0xc0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0}, 0, 0}}, yichzudprcmp, &jpuadoedqgtk };
static const struct jzrjinarvghn djmklafcchrg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0e, 1, sguttdsgjuwf }, { 0, 0, 0x07, 0, qxpgycjvroxx}, { 0, 0, 0x30, 4, ebyvbnhclkti}, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, &vycrygsmmmsk };
static const struct jzrjinarvghn tqdnhjnybmhb = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 134, {35,32,35,32}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0, 0, 0x07, 0, rzhkjkzsqdda }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, nrafnhsnjctc, &ksdjjvlyxnos };
static const struct jzrjinarvghn echqbbapacvj = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 134, {35,32,35,32}, { 0, 1, 0x0f, 0, dmsshfwhqacd }, { 0, 0, 0x07, 0, rzhkjkzsqdda }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, nrafnhsnjctc, &qrprhsyjzeeq };
static const struct jzrjinarvghn qepzyzezwhuu = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xe0, 5, kketfaufdqvt }, { 0, 1, 0x07, 0, okmydbbbrxta }, { 0, 2, 0x07, 0, eqdjldrmitax }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 1, 0xc0}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0}, 0, 0}}, yichzudprcmp, &wpegijxggepa };
static const struct jzrjinarvghn zepbjhyycphm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 1, 0x7e, 1, igcregcudtsx }, { 0, 4, 0x0e, 1, wuuswvrbariz }, { 0, 4, 0x70, 4, vubnovfywcwm }, { 0, 5, 0xff, 0, fmugcjfgcscj }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 4, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, tvxxnczaflhd, &dkoueixsmplc };
static const struct jzrjinarvghn pwhrolshogyj = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 40, {24, 8, 8, 0}, { 1, 0, 0xe0, 5, hkpjcpgsdhqe }, { 0, 1, 0x70, 4, ovaogbiheykl }, { 0, 1, 0x03, 0, vubnovfywcwm }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0,9},2,0x11}}, ervaejuksmrw, &poaldzlryirp };
static const struct jzrjinarvghn ahyyozmtuqvb = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 104, {16, 88, 0, 0}, { 1, 1, 0x7e, 1, igcregcudtsx }, { 1, 2, 0x07, 0, ukcxyrabmydo }, { 1, 2, 0x38, 3, rlohtdspsezy }, { 0, 0, 0, 0, NULL }, &zmyyggphojsb, {.buhyvlrkmues.oeiaiwqhculr = {{1, 9}, 2, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, xhzoapezwhhv, &nhdokmlnodit };
static const struct jzrjinarvghn lgqroukgtdfo = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0xf0, 4, ifrpcfykwsct }, { 0, 3, 0x07, 0, gwgdwghbwqvm }, { 0, 2, 0x03, 0, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 2, 0x07}, .buhyvlrkmues.cuoycwtsmtjr = {{0,0},0,0}}, bdyhkgjgowgw, &xltihsgzmzia };
static const struct jzrjinarvghn umwcmmmlsxmq = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfc, 2, buapomigirnj }, { 3, 5, 0x70, 4, thzgkhzxcbmo }, { 3, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL }, &xgllypiasniq, {.buhyvlrkmues.oeiaiwqhculr = {{3, 9}, 5, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{3, 9}, 9, 0x0f}}, jfvkocmnqbrv, &mrzzsmvruigr };
static const struct jzrjinarvghn jcmctrfcgupd = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 312, {160, 152, 0, 0}, { 1, 6, 0xfe, 1, ztllrbdaneil }, { 1, 5, 0x70, 4, thzgkhzxcbmo }, { 1, 8, 0xf0, 4, jawjcodvnury }, { 0, 0, 0, 0, NULL }, &qgykejxdlosa, {.buhyvlrkmues.oeiaiwqhculr = {{0, 3}, 6, 0x80}, .buhyvlrkmues.cuoycwtsmtjr = {{1, 9}, 5, 0x01}}, rzezjpgqtepn, &urxsveyojyse };
static const struct jzrjinarvghn omwgfpgtecgg = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 56, {48, 8, 0, 0}, { 0, 1, 0xfe, 1, kgrnqwzfhsuc }, { 0, 2, 0x0f, 0, zizvkbzezirx }, { 0, 2, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL }, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, iibwlluvqyeg, &dkoueixsmplc };
static const struct jzrjinarvghn dqraucmqvqdu = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 67, {35,32,0,0}, { 0, 1, 0x0f, 0, ifrpcfykwsct }, { 0, 0, 0x07, 0, anemyjwcojpq }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, dkyhokjcdqxy, &pbodbwzsmwbq };
static const struct jzrjinarvghn imuyzrgmwxjw = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 40, {32,8,0,0}, { 0, 0, 0x0f, 0, buapomigirnj }, { 0x40, 1, 0xF0, 4, puljftycpqpl }, { 0, 1, 0xF0, 4, ijpueivafadr }, { 0, 0, 0, 0, NULL}, &hzjwteowunqn, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 1, 0x01}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, tvxxnczaflhd, NULL };
static const struct jzrjinarvghn vfmyoagoggvu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 68, {68,0,0,0}, { 0, 1, 0x0f, 0, buapomigirnj }, { 0, 0, 0x07, 0, cmsxvrymmhuq }, { 0, 0, 0x30, 4, jfhuyfcvnpxj }, { 0, 0, 0, 0, NULL}, &jhgvzparnlca, {.buhyvlrkmues.oeiaiwqhculr = {{0, 9}, 0, 0x08}, .buhyvlrkmues.cuoycwtsmtjr = {{0, 0}, 0, 0}}, bdyhkgjgowgw, NULL };
static const struct jzrjinarvghn* kkegupkdbpzw[] = { &pvbmujsajrfc, &ilvymvgggkow, &lmhexsamiflb, &vbiehzleeabs, &wkmqrlymjyed, &dninvymxmyrr, &heqgejdnnetb, &bkbcyciovdgk, &xdaogblcbnft, &dztwkxkfoauw, &txtbvqixrhxi, &xlgopwqmcfvp, &qvotqxdvaist, &sqpbazfxatce, &ltaqmbndxryb, &rqxbmkhftkme, &qgegepurwkmq, &limefgaolscg, &aepdmkpyeiok, &cilgyidcbwrs, &kjatafbipoic, &xfvjbtdpjjez, &iwtorypskysb, &lvhzteagbvmh, &kzegjqujbufa, &bwtgxoxaslxp, &apqjwblvlscx, &wqgvzlptloyy, &fjjluaenjxsw, &yjcegvrzyqki, &mfyphkdocbrg, &qailxirqucha, &wugujjtnqjpn, &kbaazfskvgmp, &epmrjcsnvntz, &futoxazegnjo, &oqiojjyaezmf, &jtsanvkmqbzz, &vfipjbascnoi, &rwxfewtjkqfb, &vjkfkebjilwf, &howhgqyozbfp, &hnyokspadpsr, &teqwqtbirgba, &exgpmfjlggqq, &lbribthvwtho, &gunjycfemuqa, &qglkwdjpdrxu, &fnohhtsyvyih, &fadklifndrvp, &hohyfktauume, &wtcwmvqkihxu, &jidjptjpkyvw, &arqketchrbws, &vpfgdiwqfyko, &ynhzkuggekpp, &ywsajswcvpha, &gnwzgtsjbwwj, &vwqhhdqukkqh, &pvbehcbgjdqh, &vjdhnhdhetil, &hkbvjvvpaqta, &vmwasyntvuvd, &mngebgplstkg, &dmjdpxjikdab, &jbgkslffrhdz, &afegitdsnvyj, &vcekpwgmgywy, &aplxfmdwjgqi, &aaedijmibvbg, &ukoldirljcac, &xrtmskpmzrtr, &jrexyjtrfpme, &hqpdxipmpnvb, &hxuwpefwgrvn, &udbneafgmgtq, &osvqmokxbcge, &gswdpuhyngdl, &lmlntvlfgpaa, &daadzbfpjoco, &okudxoulzygm, &gdmumvajjiks, &bpjfcghrplyk, &utcbopooyjus, &xmbhknleeuxj, &ltkgkyaviwqy, &jffejbtfasnf, &jkaxjnaqefzl, &rpptlkdehakw, &xntydomqjghs, &qcnnhftegxbd, &eqqcxmgoacbk, &ishkxbxovmyf, &wcimpbpskbzn, &sdplgjulsshq, &mvjacrgmcqrk, &mlkbpgmieafx, &mgegaqaudmeb, &ldvricuzlhei, &ssmzuiojchvw, &ksgdnhnsejcu, &fcbmwwygvzuj, &wuawekcnekev, &kuccxgoytweu, &wanfwuugxpdp, &xgkfploforqx, &qdwjilmfujck, &vcnwkygcwhox, &ycntaxvuagcn, &pkozxtmdahpc, &ebttfdlxpgxl, &cedjyysahwcr, &hnmelkjbfkcs, &dbrrkrvscasz, &xhrlrdsgofsy, &fmgrvffxzvfc, &qdrlsbrlhnox, &aodjsvylqyfu, &nlltmejzaquu, &zvvgzcuptmpq, &ljxdgwlfbbcd, &gmqhochxbadi, &sfgzdfpfrntr, &efjqotwzdbde, &blzdlbvzjblu, &ldijdogdukeh, &xqgurcrczyec, &hygznuckhely, &yjxgivcmzqfq, &rfpjqvkvwpmw, &vfjpdfhhswbj, &afxwpwzkwwrh, &gqpjzithfcoj, &kfwreqkeeksk, &aoktqrucczue, &dvkewhqehvbw, &pnqnburnypaq, &pdpbhpsrdzte, &ursiqadbboai, &qqvpmugiynid, &hvcqznvscprl, &uhfjezgbsofu, &qbotksdrxqrl, &cudninqnhgjf, &oszlwdaaadcw, &rksqpekqbyoe, &zyktloxcjifq, &wdroysvelmxk, &yomytksmgafd, &pmjbesxlbtes, &bebymlgawlom, &hdeflxmuqarj, &nnuuammvmdln, &cxolyossrxql, &vctlqrvgvigt, &oxoygbdmyemz, &xoubnmlsdswl, &dautzyxzumwh, &raoyzhsysika, &luhpqllnqrdk, &rehwlieguuks, &xxhoisqdnlzy, &velzktpwwlna, &chqchazhcfin, &pmwdsaplucat, &maxdzzxeqadm, &ngkmzydxxlee, &mcvbgkipiplb, &sialocyhttlp, &papepyqgskxe, &dubtokmtqggq, &wedwcvluyyuq, &uugdtdvjifjt, &euczfbljmojw, &kjwghvetgtpj, &uvpczyuskkkn, &yqcpkcrctrox, &dnlhjvqbvfnv, &fritlcgpexju, &gvjaoivbvlft, &qjesznafxjoi, &ntljcectdgxc, &ashhoqgkbtrz, &etncmnganrac, &gjbxhanazzan, &hukfncckyaru, &reznbthidfio, &bzeafqixpbgp, &mqkgugnpfqmu, &ndbjtpwplnsj, &cpthvncrpezz, &rbplxipbfxrn, &qthyjxpnacge, &mjoudrvtifda, &eivcuwkmjmyy, &ffgmyumzqqbo, &fdfqwxqedzfk, &xkgqlyhqnrkb, &tqmesnejmjio, &avmsygiqppuf, &rqaaemputfsz, &zjrcitgyiyvg, &nutgrilanbjx, &rsgubciiffcf, &pmqswaualwhp, &ibjkosbbufbq, &kcaxehdponvp, &wkabhnqlzujr, &kncnqxewqlze, &bhkloqyxpyxq, &orwgusyyouri, &cqduocvilsiv, &jhmimsougmax, &isxmfxprujij, &heahpeopqgwb, &xrxeqoncgzhw, &smwbdffluovl, &zialejqfzsio, &duvdqmzcsqak, &ztatpjfibwlx, &weujghnvyndw, &ybluiyzkisqk, &alaekjxpzbkd, &trxqzlbnsqnp, &qhcxpgvmajbc, &ukpsalkgowar, &vgozoionavgd, &xrhpswddthgh, &fspygxzwnkkz, &mooqezgtowrx, &ceoalankzpjd, &mpoipupheqbm, &wfznitbkmzgy, &yiexfzyuakpb, &jemgcilepxyr, &vstqeiwmioor, &oqfdddifvzle, &xkkhmbnwdgvp, &agtbopkraeot, &dalzafbsdwwq, &mjqlajgqjenq, &jfqbhwpmtjrb, &bfpblayggzfp, &oortzxaheers, &iajpndojcexc, &nuivbdiarbvb, &txpmqgvaddpm, &tiflxuaxfahj, &qeneswuwzfix, &yqsawaquvssz, &fgkokdzmpmbv, &dbseuwxsoigd, &inxntmuissfe, &itvfwtfiwhgo, &wicwaspfhaet, &uqrciehbxhja, &rsoscflyxtpd, &zezpyzgzlpwh, &chlcfvsitqam, &ifvfppnsregz, &kqryzismnwvq, &zbbbqfxxafxa, &pdrkucllfctr, &qfencfwqaemo, &vhoqsybwxvii, &iygzwypjstpx, &betiwafeckrb, &vkbsixoeqrku, &uzgimvnlvmox, &tcvkzlbmgnxz, &mouajiapoqgd, &rjcujhmjcxlp, &fsybkwuxtyus, &avkknyarswma, &yjtddijhglgg, &watfrrskgzna, &vvfybqkrhfxk, &ybppuoltxsxa, &yjbanrpjklab, &dlxxrrjgsjcp, &tmhccfnvhlnc, &tdrgyunqmehi, &pzmbktgjwzqy, &sihswuahetxi, &jglfryytmykj, &mvyctzucpqog, &bscwnkwnrqst, &gkedycgrikvv, &arkeynlsaake, &gfsmqnbrgxdm, &xxrzflzknzns, &fbvkagozgblg, &vaiktfbqltsi, &udhjhijmuhkc, &icvzydwgywmn, &cxmhfrvnxafa, &ljxbngcbojsa, &catiaveohgfk, &bxmahmbdzgeg, &xuwpsxrewyix, &odijkqudwvrd, &djmklafcchrg, &tqdnhjnybmhb, &echqbbapacvj, &qepzyzezwhuu, &zepbjhyycphm, &pwhrolshogyj, &ahyyozmtuqvb, &lgqroukgtdfo, &umwcmmmlsxmq, &jcmctrfcgupd, &omwgfpgtecgg, &dqraucmqvqdu, &erzqxjwqllkw, &kmsilceuotxy, &rvzizqwfxphi, &ttvzvpazowgj, &imuyzrgmwxjw, &vfmyoagoggvu,
#ifndef _NO_DEPRECATED
&ijnzxwmmbvrz, &etdigqhbjjsq, &aoanqczuvzgi, &uuzvdmcjgkeb, &ebfejqvupbin, &tvoromxodhvl,
#endif
};
static const uint16_t saxoggodtxyn=sizeof(kkegupkdbpzw)/sizeof(struct jzrjinarvghn*);
static uint8_t aquknpkkmtpz(const mqbafetntzql* ytlcwydutkha, uint8_t vvqqmposfvno, bool intycnnohsss) { uint8_t ybkcazqundhq;
uint8_t oostzewziqkq;
uint8_t tvetfgwwszri = 0;
if (ytlcwydutkha->ytlcwydutkha != NULL) { ybkcazqundhq = (dzsumcvcsfvg[ytlcwydutkha->mopbcjzgmcja&0x03][ytlcwydutkha->kuaqjbcvpyes&0x3f]&ytlcwydutkha->zlrtbaktlyzx)>>(ytlcwydutkha->lzcfsjwbnffw&0x07);
oostzewziqkq = ytlcwydutkha->ytlcwydutkha[vvqqmposfvno]&(ytlcwydutkha->zlrtbaktlyzx>>(ytlcwydutkha->lzcfsjwbnffw&0x07));
if (ytlcwydutkha->mopbcjzgmcja&0x20) { const struct mnbpqhzlmcjq* mmgypycezunq = (const struct mnbpqhzlmcjq*)(ytlcwydutkha->ytlcwydutkha);
oostzewziqkq = ((const uint8_t*)mmgypycezunq->zogvzqcdcrgi)[vvqqmposfvno];
} if (!(ytlcwydutkha->mopbcjzgmcja & 0x40) || intycnnohsss) { if (ytlcwydutkha->kuaqjbcvpyes & 0x80) { tvetfgwwszri = ((oostzewziqkq&0xf0)-(ybkcazqundhq&0xf0)) | ((oostzewziqkq-ybkcazqundhq)&0x0f);
} else if (ytlcwydutkha->kuaqjbcvpyes & 0x40) { tvetfgwwszri = ((oostzewziqkq>>4)+(oostzewziqkq&0x0f)) - ((ybkcazqundhq>>4)+(ybkcazqundhq&0x0f));
} else { tvetfgwwszri = oostzewziqkq - ybkcazqundhq;
} } if (intycnnohsss) { dzsumcvcsfvg[ytlcwydutkha->mopbcjzgmcja&0x03][ytlcwydutkha->kuaqjbcvpyes&0x3f] = (dzsumcvcsfvg[ytlcwydutkha->mopbcjzgmcja&0x03][ytlcwydutkha->kuaqjbcvpyes&0x3f]&(~ytlcwydutkha->zlrtbaktlyzx)) | ((oostzewziqkq<<(ytlcwydutkha->lzcfsjwbnffw&0x07))&ytlcwydutkha->zlrtbaktlyzx);
} } return tvetfgwwszri;
} static uint8_t nchrmzxsrkgy(const mqbafetntzql* ytlcwydutkha, uint8_t vvqqmposfvno, bool intycnnohsss) { uint8_t tvetfgwwszri = 0;
uint8_t zwkeegcjawso;
const mqbafetntzql* gsssrwclidke;
if (ytlcwydutkha->mopbcjzgmcja&0x10) { gsssrwclidke = (const mqbafetntzql*)ytlcwydutkha->ytlcwydutkha;
for (zwkeegcjawso=0; zwkeegcjawso<ytlcwydutkha->lzcfsjwbnffw; zwkeegcjawso++)
{ tvetfgwwszri |= aquknpkkmtpz(&gsssrwclidke[zwkeegcjawso], vvqqmposfvno, intycnnohsss);
} } else { tvetfgwwszri = aquknpkkmtpz(ytlcwydutkha, vvqqmposfvno, intycnnohsss);
} return tvetfgwwszri;
} static bool enbovseslkvh(const struct jzrjinarvghn* mfziljnihjsa, bool hiukkmirrlxz) { uint8_t zwkeegcjawso = 0;
algorithm_t uojpydwzkpuv;
htztnpskwcvl = NULL;
while (mfziljnihjsa->xvskvavzjiht[zwkeegcjawso].xbjpducmipqs != NULL) { uojpydwzkpuv = mfziljnihjsa->xvskvavzjiht[zwkeegcjawso].xbjpducmipqs;
if (!uojpydwzkpuv(mfziljnihjsa, mfziljnihjsa->xvskvavzjiht[zwkeegcjawso].enbbaqhuguke, hiukkmirrlxz)) { return false;
} zwkeegcjawso++;
} return true;
} static bool wefxmuqqkamb(const struct smyuzdtplpcq* buhyvlrkmues, bool hiukkmirrlxz) { uint8_t ykbqepaaehvx;
ykbqepaaehvx = dzsumcvcsfvg[buhyvlrkmues->nqjsrsnaymrk.tuxqdptrerhp][buhyvlrkmues->kuaqjbcvpyes];
if (hiukkmirrlxz) { dzsumcvcsfvg[buhyvlrkmues->nqjsrsnaymrk.tuxqdptrerhp][buhyvlrkmues->kuaqjbcvpyes] = psrggqspjmka[buhyvlrkmues->nqjsrsnaymrk.uzmxwkhdlkjl](ykbqepaaehvx, buhyvlrkmues->bits);
return true;
} else { return dzsumcvcsfvg[buhyvlrkmues->nqjsrsnaymrk.tuxqdptrerhp][buhyvlrkmues->kuaqjbcvpyes] == psrggqspjmka[buhyvlrkmues->nqjsrsnaymrk.uzmxwkhdlkjl](ykbqepaaehvx, buhyvlrkmues->bits);
} } static void vbkcmqwzkjcy(bc7215DataVarPkt_t* ejlhruakwgum, int8_t dtgjdieluhic, uint8_t iabtzozgxhmj) { uint8_t zwkeegcjawso;
int8_t fscddfgvwdlc;
bool rnaajnxftbss=0;
for (zwkeegcjawso=0; zwkeegcjawso<iabtzozgxhmj; zwkeegcjawso++)
{ for (fscddfgvwdlc=(ejlhruakwgum->bitLen+7)/8-1; fscddfgvwdlc>=dtgjdieluhic; fscddfgvwdlc--)
{ if (ejlhruakwgum->data[fscddfgvwdlc] & 0x80) { ejlhruakwgum->data[fscddfgvwdlc] <<= 1;
if (rnaajnxftbss == 1) { ejlhruakwgum->data[fscddfgvwdlc] |= 0x01;
} rnaajnxftbss = 1;
} else { ejlhruakwgum->data[fscddfgvwdlc] <<= 1;
if (rnaajnxftbss == 1) { ejlhruakwgum->data[fscddfgvwdlc] |= 0x01;
} rnaajnxftbss = 0;
} } } } static void ljpgmoirhflm(bc7215DataVarPkt_t* ejlhruakwgum, int8_t dtgjdieluhic, uint8_t iabtzozgxhmj) { uint8_t zwkeegcjawso;
int8_t fscddfgvwdlc;
bool rnaajnxftbss=0;
for (zwkeegcjawso=0; zwkeegcjawso<iabtzozgxhmj; zwkeegcjawso++)
{ for (fscddfgvwdlc=(ejlhruakwgum->bitLen+7)/8-1; fscddfgvwdlc>=dtgjdieluhic; fscddfgvwdlc--)
{ if (ejlhruakwgum->data[fscddfgvwdlc] & 0x01) { ejlhruakwgum->data[fscddfgvwdlc] >>= 1;
if (rnaajnxftbss == 1) { ejlhruakwgum->data[fscddfgvwdlc] |= 0x80;
} rnaajnxftbss = 1;
} else { ejlhruakwgum->data[fscddfgvwdlc] >>= 1;
if (rnaajnxftbss == 1) { ejlhruakwgum->data[fscddfgvwdlc] |= 0x80;
} rnaajnxftbss = 0;
} } } } static void zlgfxmvzkalt(uint8_t nqjsrsnaymrk[][BC7215_MAX_RX_DATA_SIZE], bc7215DataVarPkt_t* ejlhruakwgum, const struct jzrjinarvghn* mfziljnihjsa) { uint16_t sptzbtionfyb = 0;
uint8_t xbecxfhqrcrs = 0;
uint8_t zwkeegcjawso;
uint8_t ghkcctcgdsls = 0;
uint8_t otihgeqjidfo;
uint8_t jrvscqwhlsxu;
uint16_t ublpolrfleta;
ublpolrfleta = mfziljnihjsa->tihyumdayysw[0]+mfziljnihjsa->tihyumdayysw[1]+mfziljnihjsa->tihyumdayysw[2]+mfziljnihjsa->tihyumdayysw[3];
while (sptzbtionfyb < ublpolrfleta) { otihgeqjidfo = ghkcctcgdsls+(mfziljnihjsa->tihyumdayysw[xbecxfhqrcrs]+7)/8;
for (zwkeegcjawso=ghkcctcgdsls; zwkeegcjawso<otihgeqjidfo; zwkeegcjawso++)
{ nqjsrsnaymrk[xbecxfhqrcrs][zwkeegcjawso-ghkcctcgdsls] = ejlhruakwgum->data[zwkeegcjawso];
} jrvscqwhlsxu = mfziljnihjsa->tihyumdayysw[xbecxfhqrcrs]%8;
if (jrvscqwhlsxu != 0) { if ((mfziljnihjsa->signature&0x30) == 0x30) { nqjsrsnaymrk[xbecxfhqrcrs][otihgeqjidfo-ghkcctcgdsls-1] &= xdfisseiufld[jrvscqwhlsxu];
ljpgmoirhflm(ejlhruakwgum, otihgeqjidfo-1, jrvscqwhlsxu);
} else { nqjsrsnaymrk[xbecxfhqrcrs][otihgeqjidfo-ghkcctcgdsls-1] &= qafpuptaxgyf[jrvscqwhlsxu];
vbkcmqwzkjcy(ejlhruakwgum, otihgeqjidfo-1, jrvscqwhlsxu);
} ghkcctcgdsls = otihgeqjidfo-1;
} else { ghkcctcgdsls = otihgeqjidfo;
} sptzbtionfyb += mfziljnihjsa->tihyumdayysw[xbecxfhqrcrs];
xbecxfhqrcrs++;
} } static uint8_t uurdlftbhnrr(uint8_t byte) { return (dtzcgmqmhfdd[byte & 0x0F] << 4) | dtzcgmqmhfdd[byte >> 4];
} static uint8_t aupzgmyawpwf(uint8_t byte) { return (qpewgelzvrjj[byte >> 4]<<4) | qpewgelzvrjj[byte & 0x0f];
} static void uepqnkyltcbw(const struct jzrjinarvghn* mfziljnihjsa) { uint8_t zwkeegcjawso, fscddfgvwdlc;
for (zwkeegcjawso=0; zwkeegcjawso<4; zwkeegcjawso++)
{ for (fscddfgvwdlc=0; fscddfgvwdlc<(mfziljnihjsa->tihyumdayysw[zwkeegcjawso]+7)/8; fscddfgvwdlc++)
{ dzsumcvcsfvg[zwkeegcjawso][fscddfgvwdlc] = uurdlftbhnrr(dzsumcvcsfvg[zwkeegcjawso][fscddfgvwdlc]);
} } } static void mcftdsxoagub(const struct jzrjinarvghn* mfziljnihjsa) { uint8_t zwkeegcjawso, fscddfgvwdlc;
for (zwkeegcjawso=0; zwkeegcjawso<4; zwkeegcjawso++)
{ for (fscddfgvwdlc=0; fscddfgvwdlc<(mfziljnihjsa->tihyumdayysw[zwkeegcjawso]+7)/8; fscddfgvwdlc++)
{ dzsumcvcsfvg[zwkeegcjawso][fscddfgvwdlc] = aupzgmyawpwf(dzsumcvcsfvg[zwkeegcjawso][fscddfgvwdlc]);
} } } static bool giokrvdulifd(const struct jzrjinarvghn* mfziljnihjsa) { uint8_t dncafvgrpkau;
if (pfipaetctpwp) { if (envgkvyuvctc->fihqcdjkaqjh != NULL) { dncafvgrpkau = envgkvyuvctc->fihqcdjkaqjh->iezimrbuhymx[flslgruxmtxo-60];
} else { dncafvgrpkau = dirhnlinsrls.iezimrbuhymx[flslgruxmtxo-60];
} } else { dncafvgrpkau = xcqbznndjhij-16;
} if (aquknpkkmtpz(&mfziljnihjsa->lkytgmwsvbjc, dncafvgrpkau, zyydpgxliaif) != 0) { return false;
} if (aquknpkkmtpz(&mfziljnihjsa->zagbhfvgdmex, MODE_COOL, zyydpgxliaif) != 0) { return false;
} return enbovseslkvh(mfziljnihjsa, zyydpgxliaif);
} static int8_t iqvyumnaknul(const mqbafetntzql* ytlcwydutkha, uint8_t evnhgikphnwk) { mqbafetntzql vrrexlvgydoa = *ytlcwydutkha;
int8_t zwkeegcjawso;
vrrexlvgydoa.mopbcjzgmcja &= 0x3F;
zwkeegcjawso = evnhgikphnwk/2;
while (zwkeegcjawso >= 0) { if (aquknpkkmtpz(&vrrexlvgydoa, zwkeegcjawso, zyydpgxliaif) == 0) { return zwkeegcjawso;
} zwkeegcjawso--;
} for (zwkeegcjawso=evnhgikphnwk/2+1; zwkeegcjawso<evnhgikphnwk; zwkeegcjawso++)
{ if (aquknpkkmtpz(&vrrexlvgydoa, zwkeegcjawso, zyydpgxliaif) == 0) { return zwkeegcjawso;
} } return -1;
} static int8_t ljjyonmpujjk(const struct ldftspiijtra* ayxdpayfilci) { int8_t zwkeegcjawso;
int8_t keudqpeeoqdm, kldwjpbbqsaq;
int8_t oslsllbntxul = -1;
mqbafetntzql vrrexlvgydoa = envgkvyuvctc->lkytgmwsvbjc;
vrrexlvgydoa.mopbcjzgmcja &= 0x3f;
for (zwkeegcjawso=0; zwkeegcjawso<15; zwkeegcjawso++)
{ keudqpeeoqdm = 14-zwkeegcjawso;
kldwjpbbqsaq = 15+zwkeegcjawso;
if (aquknpkkmtpz(&vrrexlvgydoa, ayxdpayfilci->iezimrbuhymx[keudqpeeoqdm], zyydpgxliaif) == 0) { oslsllbntxul = keudqpeeoqdm;
if (ayxdpayfilci->wwoykbnvyqzp.ytlcwydutkha != NULL ) { if (nchrmzxsrkgy(&ayxdpayfilci->wwoykbnvyqzp, keudqpeeoqdm, zyydpgxliaif) == 0) { return oslsllbntxul;
} } } if ((kldwjpbbqsaq<=28) && (aquknpkkmtpz(&vrrexlvgydoa, ayxdpayfilci->iezimrbuhymx[kldwjpbbqsaq], zyydpgxliaif) == 0)) { oslsllbntxul = kldwjpbbqsaq;
if (ayxdpayfilci->wwoykbnvyqzp.ytlcwydutkha != NULL ) { if (nchrmzxsrkgy(&ayxdpayfilci->wwoykbnvyqzp, kldwjpbbqsaq, zyydpgxliaif) == 0) { return oslsllbntxul;
} } } } return oslsllbntxul;
} static int8_t hhhchexgkldv(const struct jzrjinarvghn* mfziljnihjsa) { int8_t vmjindlfsbxu;
uint16_t	cywpppiwvowx=0;
const bc7215DataVarPkt_t*	hloudcurtwah;
vmjindlfsbxu = 1;
if (!mfziljnihjsa->spec.meugerfooagb) { if ((mfziljnihjsa->jyzhocqchyzz.ytlcwydutkha != NULL) && (mfziljnihjsa->jyzhocqchyzz.ytlcwydutkha[0] != mfziljnihjsa->jyzhocqchyzz.ytlcwydutkha[4]) && !((mfziljnihjsa->lkytgmwsvbjc.mopbcjzgmcja&0x80) || (mfziljnihjsa->zagbhfvgdmex.mopbcjzgmcja&0x80) || (mfziljnihjsa->efzkaswlxsjp.mopbcjzgmcja&0x80))) { if (aquknpkkmtpz(&mfziljnihjsa->jyzhocqchyzz, 4, zyydpgxliaif) == 0) { if (mfziljnihjsa->jyzhocqchyzz.ytlcwydutkha[4] == mfziljnihjsa->jyzhocqchyzz.ytlcwydutkha[5]) { vmjindlfsbxu = 2;
} else { vmjindlfsbxu = 0;
return vmjindlfsbxu;
} } } if ( !( (envgkvyuvctc->tbqxbwmytmil.buhyvlrkmues.oeiaiwqhculr.nqjsrsnaymrk.uzmxwkhdlkjl == 0) && (envgkvyuvctc->tbqxbwmytmil.buhyvlrkmues.oeiaiwqhculr.bits == 0) && (envgkvyuvctc->tbqxbwmytmil.buhyvlrkmues.cuoycwtsmtjr.nqjsrsnaymrk.uzmxwkhdlkjl == 0) && (envgkvyuvctc->tbqxbwmytmil.buhyvlrkmues.cuoycwtsmtjr.bits == 0) ) ) { if (!vbsdeujddnxr) { if ( wefxmuqqkamb(&envgkvyuvctc->tbqxbwmytmil.buhyvlrkmues.oeiaiwqhculr, zyydpgxliaif) && wefxmuqqkamb(&envgkvyuvctc->tbqxbwmytmil.buhyvlrkmues.cuoycwtsmtjr, zyydpgxliaif) ) { vmjindlfsbxu = 0;
} else if (vmjindlfsbxu == 2) { vmjindlfsbxu = 1;
} } if (mfziljnihjsa->spec.jkzmicqrmkcx) { if (vmjindlfsbxu == 1) { vmjindlfsbxu = -1;
} else { vmjindlfsbxu = 2;
} } } } else { hloudcurtwah = bc7215_ac_off();
if (hloudcurtwah != NULL) { if (hloudcurtwah->bitLen != 0) { cywpppiwvowx = hloudcurtwah->bitLen;
} else { cywpppiwvowx = ((const bc7215CombinedMsg_t*)hloudcurtwah)->body.msg.datPkt->bitLen;
} } if ((cywpppiwvowx == mfziljnihjsa->bitLen) && cobiupqigoqa((bc7215DataVarPkt_t*)&sapcqlhnefas)) { if (mfziljnihjsa->spec.jkzmicqrmkcx) { vmjindlfsbxu = 2;
} else { vmjindlfsbxu = 0;
} } } return vmjindlfsbxu;
} static uint8_t gwndyyoirsol(uint8_t ejlhruakwgum, uint8_t bits, uint8_t* addawvizwcnk) { uint8_t byte;
if ((bits != 8) && (bits != 0)) { byte = ejlhruakwgum&xdfisseiufld[bits];
ejlhruakwgum >>= bits;
ejlhruakwgum |= (*addawvizwcnk<<(8-bits));
*addawvizwcnk = byte;
} return ejlhruakwgum;
} static uint8_t ivietcxfhoig(uint8_t ejlhruakwgum, uint8_t bits, uint8_t* addawvizwcnk) { uint8_t byte;
if ((bits != 8) && (bits != 0)) { byte = ejlhruakwgum&qafpuptaxgyf[bits];
ejlhruakwgum <<= bits;
ejlhruakwgum |= (*addawvizwcnk>>(8-bits));
*addawvizwcnk = byte;
} return ejlhruakwgum;
} static void drrrdscymaou(const struct jzrjinarvghn* mfziljnihjsa) { uint8_t mopbcjzgmcja;
uint16_t fscddfgvwdlc;
uint8_t pqmzwjapyvga = 0;
uint16_t eqreivjjxhnp = 0;
uint8_t xkphgvyllpkk = 0;
uint8_t jkbogonhxsfl = 0;
uint8_t iabtzozgxhmj = 0;
uint8_t essrwvtkedpy;
ziciuqwubgaa.bitLen = mfziljnihjsa->bitLen;
for (mopbcjzgmcja = 0; mopbcjzgmcja < 4; mopbcjzgmcja++) {
if (mfziljnihjsa->tihyumdayysw[mopbcjzgmcja] != 0) { for (fscddfgvwdlc = 0; fscddfgvwdlc < (mfziljnihjsa->tihyumdayysw[mopbcjzgmcja]-iabtzozgxhmj+7)/8; fscddfgvwdlc++) {
xkphgvyllpkk = ullmnppxxckm[mopbcjzgmcja][fscddfgvwdlc+1];
if ((mfziljnihjsa->signature&0x30) == 0x30) { ziciuqwubgaa.data[pqmzwjapyvga] = gwndyyoirsol(ullmnppxxckm[mopbcjzgmcja][fscddfgvwdlc], iabtzozgxhmj, &xkphgvyllpkk);
} else { ziciuqwubgaa.data[pqmzwjapyvga] = ivietcxfhoig(ullmnppxxckm[mopbcjzgmcja][fscddfgvwdlc], iabtzozgxhmj, &xkphgvyllpkk);
} pqmzwjapyvga++;
} eqreivjjxhnp += mfziljnihjsa->tihyumdayysw[mopbcjzgmcja];
jkbogonhxsfl = eqreivjjxhnp%8;
iabtzozgxhmj = (8-jkbogonhxsfl)&0x07;
if ((iabtzozgxhmj != 0) && (mopbcjzgmcja != 3) && (mfziljnihjsa->tihyumdayysw[mopbcjzgmcja+1] != 0)){ if ((mfziljnihjsa->signature&0x30) == 0x30) { ziciuqwubgaa.data[pqmzwjapyvga-1] = (ziciuqwubgaa.data[pqmzwjapyvga-1]&xdfisseiufld[jkbogonhxsfl]) | (ullmnppxxckm[mopbcjzgmcja+1][0] << jkbogonhxsfl);
} else { ziciuqwubgaa.data[pqmzwjapyvga-1] = (ziciuqwubgaa.data[pqmzwjapyvga-1]&qafpuptaxgyf[jkbogonhxsfl]) | (ullmnppxxckm[mopbcjzgmcja+1][0] >> jkbogonhxsfl);
} } } } if (mfziljnihjsa->spec.vrpqfnokrnbi && mfziljnihjsa->spec.mvpxvriwlnzh) { memcpy(jzrbzxjvujig.data, ziciuqwubgaa.data, (ziciuqwubgaa.bitLen+7)/8);
memcpy(ziciuqwubgaa.data, sapcqlhnefas.data, (ziciuqwubgaa.bitLen+7)/8);
eqreivjjxhnp = 0;
for (fscddfgvwdlc=0; fscddfgvwdlc<ziciuqwubgaa.bitLen/2; fscddfgvwdlc++)
{ pqmzwjapyvga = fscddfgvwdlc/4;
essrwvtkedpy = ziciuqwubgaa.data[pqmzwjapyvga] & yjkmododoujl[fscddfgvwdlc%4];
if ((essrwvtkedpy & 0xaa) == 0) { if (jzrbzxjvujig.data[eqreivjjxhnp/8] & gjpklnywlizj[eqreivjjxhnp%8]) { ziciuqwubgaa.data[pqmzwjapyvga] = (ziciuqwubgaa.data[pqmzwjapyvga]&(~yjkmododoujl[fscddfgvwdlc%4])) | (0x55 & yjkmododoujl[fscddfgvwdlc%4]);
} else { ziciuqwubgaa.data[pqmzwjapyvga] = ziciuqwubgaa.data[pqmzwjapyvga] & (~yjkmododoujl[fscddfgvwdlc%4]);
} eqreivjjxhnp++;
} } } } static void qgcqefcklmta(const struct jzrjinarvghn* mfziljnihjsa, uint8_t nhxxzxrljjtk, const bc7215DataVarPkt_t* ejlhruakwgum) { uint8_t zmhpcahvuugt;
uint8_t fscddfgvwdlc, k;
uint16_t eqreivjjxhnp;
uint8_t essrwvtkedpy;
eqreivjjxhnp = 0;
jzrbzxjvujig.bitLen = ejlhruakwgum->bitLen;
zmhpcahvuugt = (ejlhruakwgum->bitLen+7)/8;
for (fscddfgvwdlc=0; fscddfgvwdlc<zmhpcahvuugt; fscddfgvwdlc++) {
if (mfziljnihjsa->spec.vrpqfnokrnbi && mfziljnihjsa->spec.mvpxvriwlnzh) { for (k= 0; k < 4; k++) {
essrwvtkedpy = ejlhruakwgum->data[fscddfgvwdlc] & yjkmododoujl[k];
if ((essrwvtkedpy & 0xaa) == 0) { if ((essrwvtkedpy & 0x55) == 0) { jzrbzxjvujig.data[eqreivjjxhnp/8] &= ~gjpklnywlizj[eqreivjjxhnp%8];
} else { jzrbzxjvujig.data[eqreivjjxhnp/8] |= gjpklnywlizj[eqreivjjxhnp%8];
} eqreivjjxhnp++;
} } } else if (nhxxzxrljjtk&0x40) { jzrbzxjvujig.data[fscddfgvwdlc] = ~ejlhruakwgum->data[fscddfgvwdlc];
} else { jzrbzxjvujig.data[fscddfgvwdlc] = ejlhruakwgum->data[fscddfgvwdlc];
} } yqmyeoglvjxv(mfziljnihjsa, (bc7215DataVarPkt_t*)&jzrbzxjvujig);
} static void yqmyeoglvjxv(const struct jzrjinarvghn* mfziljnihjsa, bc7215DataVarPkt_t* ejlhruakwgum) { zlgfxmvzkalt(dzsumcvcsfvg, ejlhruakwgum, mfziljnihjsa);
if (mfziljnihjsa->spec.jsohiapiyung) { uepqnkyltcbw(mfziljnihjsa);
} if (mfziljnihjsa->spec.vrpqfnokrnbi && !mfziljnihjsa->spec.mvpxvriwlnzh) { mcftdsxoagub(mfziljnihjsa);
} } static void awsteilqqidy(const struct jzrjinarvghn* mfziljnihjsa) { uint8_t zwkeegcjawso, fscddfgvwdlc;
uint8_t kocenlaoxhsr;
uint8_t zmhpcahvuugt;
for (zwkeegcjawso=0; zwkeegcjawso<4; zwkeegcjawso++)
{ zmhpcahvuugt = (mfziljnihjsa->tihyumdayysw[zwkeegcjawso]+7)/8;
for (fscddfgvwdlc=0; fscddfgvwdlc<zmhpcahvuugt; fscddfgvwdlc++)
{ kocenlaoxhsr = dzsumcvcsfvg[zwkeegcjawso][fscddfgvwdlc];
if (mfziljnihjsa->spec.vrpqfnokrnbi && !mfziljnihjsa->spec.mvpxvriwlnzh) { kocenlaoxhsr = aupzgmyawpwf(kocenlaoxhsr);
} if (mfziljnihjsa->spec.jsohiapiyung) { kocenlaoxhsr = uurdlftbhnrr(kocenlaoxhsr);
} if (tjmnkrnjmplx & 0x40) { kocenlaoxhsr = ~kocenlaoxhsr;
} ullmnppxxckm[zwkeegcjawso][fscddfgvwdlc] = kocenlaoxhsr;
} } } static void yxrpjuurrlvu(const struct oebbqnqfnloq* enbbaqhuguke) { uint8_t uvqwpvjoxzid;
uint8_t tvetfgwwszri;
uint8_t vmjindlfsbxu;
uint8_t mgpzgiotmdzg;
mgpzgiotmdzg = enbbaqhuguke->mgpzgiotmdzg&0x03;
uvqwpvjoxzid = dzsumcvcsfvg[mgpzgiotmdzg][enbbaqhuguke->fbrvysdlrmrf];
tvetfgwwszri = (ykfwzrfuvamm[enbbaqhuguke->ixvdbojkppfu]&enbbaqhuguke->rcgwtdbxudzi)<<enbbaqhuguke->mpqeiytncxnk;
vmjindlfsbxu = psrggqspjmka[enbbaqhuguke->uzmxwkhdlkjl.uzmxwkhdlkjl](uvqwpvjoxzid, tvetfgwwszri);
uvqwpvjoxzid = (uvqwpvjoxzid&(~enbbaqhuguke->yvnopioecdgf)) | (vmjindlfsbxu&enbbaqhuguke->yvnopioecdgf);
dzsumcvcsfvg[mgpzgiotmdzg][enbbaqhuguke->fbrvysdlrmrf] = uvqwpvjoxzid;
}
#ifndef _NO_DEPRECATED
static void uszixsjynqda(void) { rjzhjhfplwrl = pivgeeqvhhpr;
kjqjwbcmhzpv = sapcqlhnefas;
}
#endif
static void habgxxtwlylz(void) { pivgeeqvhhpr = rjzhjhfplwrl;
sapcqlhnefas = kjqjwbcmhzpv;
} static bool mzizjkxcdqfk(uint16_t zfkpznexggcf) { envgkvyuvctc = kkegupkdbpzw[zfkpznexggcf];
tyxuvftnzciv = false;
if (((tjmnkrnjmplx&0xbf) == envgkvyuvctc->signature) && (sapcqlhnefas.bitLen == envgkvyuvctc->bitLen)) { qgcqefcklmta(envgkvyuvctc, tjmnkrnjmplx, (const bc7215DataVarPkt_t*)&sapcqlhnefas);
if (giokrvdulifd(envgkvyuvctc)) { if (envgkvyuvctc->zagbhfvgdmex.mopbcjzgmcja&0x20) { ((const struct mnbpqhzlmcjq*)envgkvyuvctc->zagbhfvgdmex.ytlcwydutkha)->mfziljnihjsa.tbqxbwmytmil.xhwercrymuhm(NULL, NULL);
} return true;
} } return false;
} static bool mqpgxplkfrxt(bc7215FormatPkt_t* format, uint16_t vdjolhmbfiwp, uint8_t uunzwbskiucw, uint8_t dvfxpcvcjsdb) { uint8_t zwkeegcjawso, fscddfgvwdlc, oldSpecial, newSpecial, oldTypeCnt;
uint16_t hejhcvhcrmfb;
uint8_t*  mrqryehacrba;
uint8_t*  uusctezbqoud;
if ((format == NULL) || (vdjolhmbfiwp*uunzwbskiucw > BC7215_MAX_RX_DATA_SIZE*8) || (vdjolhmbfiwp == 0) || (uunzwbskiucw > 4)) { return false;
} mrqryehacrba = (uint8_t*)format;
oldSpecial = (*mrqryehacrba&0x07)^0x05;
newSpecial =  oldSpecial*(uunzwbskiucw+1)+uunzwbskiucw;
if (newSpecial >8) { return false;
} *mrqryehacrba = (*mrqryehacrba&0xf8)+(newSpecial^5);
mrqryehacrba += 9;
oldTypeCnt = *mrqryehacrba;
*mrqryehacrba++ = (((oldTypeCnt^0x1d)&0x7f)+1)^29;
*mrqryehacrba = (*mrqryehacrba&0x80)+(newSpecial^29);
mrqryehacrba++;
if ((oldTypeCnt&0x7f) == 29) { *mrqryehacrba++ = ((*((uint8_t*)format+1)^29)/2)^29;
*mrqryehacrba = 226;
} else { mrqryehacrba = mrqryehacrba+2*(oldTypeCnt^29);
*(mrqryehacrba++) = ((*((uint8_t*)format+1)^29)+1)/2;
*mrqryehacrba = 0xff;
} uusctezbqoud = (uint8_t*)format+17;
mrqryehacrba = uusctezbqoud+oldSpecial*2;
for (fscddfgvwdlc=0; fscddfgvwdlc<uunzwbskiucw; fscddfgvwdlc++)
{ hejhcvhcrmfb = ((vdjolhmbfiwp*(fscddfgvwdlc+1)) |((oldTypeCnt^0x1d)<<12))|0x8000;
*mrqryehacrba++ = hejhcvhcrmfb&0xff;
*mrqryehacrba++ = hejhcvhcrmfb>>8;
for (zwkeegcjawso=0; zwkeegcjawso<oldSpecial; zwkeegcjawso++)
{ newSpecial = *(uusctezbqoud+zwkeegcjawso*2);
oldTypeCnt = *(uusctezbqoud+zwkeegcjawso*2+1);
hejhcvhcrmfb = (vdjolhmbfiwp*(fscddfgvwdlc+1)+ (newSpecial | ((oldTypeCnt<<8)&0x0fff))) | ((oldTypeCnt<<8)&0xf000);
*mrqryehacrba++ = hejhcvhcrmfb&0xff;
*mrqryehacrba++ = hejhcvhcrmfb>>8;
} } if (newSpecial < 8) { *((uint8_t*)format+31) = dvfxpcvcjsdb;
} return true;
}
#ifndef _NO_DEPRECATED
static void yebwpscaeong(const struct jzrjinarvghn* mfziljnihjsa) { const struct opvdfjyhetkm*  rumsintiplya;
tyxuvftnzciv = true;
uszixsjynqda();
rumsintiplya = (const struct opvdfjyhetkm*)mfziljnihjsa->lbtdeitxhjhh->set.nyqmexqqqjzu;
mqpgxplkfrxt(&pivgeeqvhhpr, sapcqlhnefas.bitLen, rumsintiplya->uunzwbskiucw, rumsintiplya->dvfxpcvcjsdb);
enbovseslkvh(rumsintiplya->mfziljnihjsa, vcabqkuncaai);
awsteilqqidy(rumsintiplya->mfziljnihjsa);
drrrdscymaou(rumsintiplya->mfziljnihjsa);
envgkvyuvctc = rumsintiplya->mfziljnihjsa;
tjmnkrnjmplx = pivgeeqvhhpr.signature.bits.sig;
bc7215_ac_replace_base(tjmnkrnjmplx, (const bc7215DataVarPkt_t*)&ziciuqwubgaa);
}
#endif
static bool bkmlskoanlff(uint16_t umetaspxyhjy, uint8_t ixvdbojkppfu, uint8_t kamhqpmzrfzs) { ixvdbojkppfu &= 0x3f;
if (kamhqpmzrfzs == 0) { kamhqpmzrfzs = 60;
} if (kamhqpmzrfzs < 37) { kamhqpmzrfzs = 37;
} if (kamhqpmzrfzs > 72) { kamhqpmzrfzs = 72;
} kamhqpmzrfzs = (kamhqpmzrfzs*7)&0xff;
if ((ixvdbojkppfu > 1) && (ixvdbojkppfu <= 4)) { if (mqpgxplkfrxt(&pivgeeqvhhpr, umetaspxyhjy, ixvdbojkppfu-1, kamhqpmzrfzs)) { return true;
} } return false;
} static bool luqxfomtfrfm(uint8_t uzqwwdupgciv, const bc7215CombinedMsg_t luuqccowyelx[]) { uint8_t zwkeegcjawso, zmhpcahvuugt;
uint16_t ivesnyicvret;
struct jzrjinarvghn rgpzmvomlhal= {0};
ivesnyicvret = 0;
uzqwwdupgciv &= 0x3f;
if ((uzqwwdupgciv > 0) && (uzqwwdupgciv <= 4)) { for (zwkeegcjawso=0; zwkeegcjawso<4; zwkeegcjawso++)
{ if ((zwkeegcjawso < uzqwwdupgciv) && (luuqccowyelx[zwkeegcjawso].body.msg.datPkt != NULL) && (luuqccowyelx[zwkeegcjawso].body.msg.datPkt->bitLen < BC7215_MAX_RX_DATA_SIZE*8)) { rgpzmvomlhal.tihyumdayysw[zwkeegcjawso] = luuqccowyelx[zwkeegcjawso].body.msg.datPkt->bitLen;
ivesnyicvret += rgpzmvomlhal.tihyumdayysw[zwkeegcjawso];
if (ivesnyicvret > BC7215_MAX_RX_DATA_SIZE*8) { return false;
} zmhpcahvuugt = (rgpzmvomlhal.tihyumdayysw[zwkeegcjawso]+7)/8;
memcpy(ullmnppxxckm[zwkeegcjawso], luuqccowyelx[zwkeegcjawso].body.msg.datPkt->data, zmhpcahvuugt);
} else { rgpzmvomlhal.tihyumdayysw[zwkeegcjawso] = 0;
} } rgpzmvomlhal.bitLen = ivesnyicvret;
rgpzmvomlhal.signature = pivgeeqvhhpr.signature.bits.sig;
drrrdscymaou(&rgpzmvomlhal);
return true;
} return false;
} static void pkynntmaadci(const struct jzrjinarvghn* mfziljnihjsa) { const ebbynksakqwk* ekvfwfegzsbn;
#ifndef _NO_DEPRECATED
if (mfziljnihjsa->jyzhocqchyzz.mopbcjzgmcja&0x80) { ekvfwfegzsbn = ((const struct opvdfjyhetkm*)mfziljnihjsa->lbtdeitxhjhh->set.nyqmexqqqjzu)->zogvzqcdcrgi;
} else { ekvfwfegzsbn = mfziljnihjsa->lbtdeitxhjhh->set.nyqmexqqqjzu;
}
#else
ekvfwfegzsbn = mfziljnihjsa->lbtdeitxhjhh->set.nyqmexqqqjzu;
#endif
while ((ekvfwfegzsbn != NULL) && (ekvfwfegzsbn->rdoojlcaxsdk != NULL)) { if ((kuisskbiyanl[ekvfwfegzsbn->ckqgxozywxmq] >= 0) && (kuisskbiyanl[ekvfwfegzsbn->ckqgxozywxmq] < 0x0f)) { dzsumcvcsfvg[ekvfwfegzsbn->mopbcjzgmcja][ekvfwfegzsbn->kuaqjbcvpyes&0x3f] = (dzsumcvcsfvg[ekvfwfegzsbn->mopbcjzgmcja][ekvfwfegzsbn->kuaqjbcvpyes&0x3f]&(~ekvfwfegzsbn->zlrtbaktlyzx)) | (ekvfwfegzsbn->rdoojlcaxsdk[kuisskbiyanl[ekvfwfegzsbn->ckqgxozywxmq]]&ekvfwfegzsbn->zlrtbaktlyzx);
} ekvfwfegzsbn++;
} } static const bc7215DataVarPkt_t* iwtxccugqtjo(uint8_t itzyykdscbwo) { qgcqefcklmta(envgkvyuvctc, tjmnkrnjmplx, (const bc7215DataVarPkt_t*)&sapcqlhnefas);
if ((itzyykdscbwo == 4) || envgkvyuvctc->spec.jkzmicqrmkcx) { wefxmuqqkamb(&envgkvyuvctc->tbqxbwmytmil.buhyvlrkmues.oeiaiwqhculr, vcabqkuncaai);
wefxmuqqkamb(&envgkvyuvctc->tbqxbwmytmil.buhyvlrkmues.cuoycwtsmtjr, vcabqkuncaai);
} ykfwzrfuvamm[0] = 0;
ykfwzrfuvamm[1] = 0;
ykfwzrfuvamm[2] = 0;
ykfwzrfuvamm[3] = aquknpkkmtpz(&envgkvyuvctc->jyzhocqchyzz, itzyykdscbwo, vcabqkuncaai);
kuisskbiyanl[0] = -1;
kuisskbiyanl[1] = -1;
kuisskbiyanl[2] = -1;
kuisskbiyanl[3] = itzyykdscbwo;
pkynntmaadci(envgkvyuvctc);
enbovseslkvh(envgkvyuvctc, vcabqkuncaai);
awsteilqqidy(envgkvyuvctc);
drrrdscymaou(envgkvyuvctc);
qgcqefcklmta(envgkvyuvctc, tjmnkrnjmplx, (const bc7215DataVarPkt_t*)&sapcqlhnefas);
if (tyxuvftnzciv) { qanfaymkryfx.body.msg.fmt = &pivgeeqvhhpr;
qanfaymkryfx.body.msg.datPkt = (bc7215DataVarPkt_t*)&ziciuqwubgaa;
return (const bc7215DataVarPkt_t*)&qanfaymkryfx;
} else { return (const bc7215DataVarPkt_t*)&ziciuqwubgaa;
} } static void wjiomkhdaafv(uint8_t hrllkahyojud, uint8_t abnmwwtopahh) { uint8_t ldbnokfmyoma;
uint8_t bloapqemhdha;
uint8_t ytlcwydutkha;
ldbnokfmyoma = hrllkahyojud >> 4 ;
bloapqemhdha = abnmwwtopahh >> 4 ;
ytlcwydutkha = abnmwwtopahh&0x0f;
if (bloapqemhdha & 0xFC) { bloapqemhdha &= 0x03;
ytlcwydutkha += 0x10;
} if ((ldbnokfmyoma < 4) && (bloapqemhdha < 4)) { if (kuisskbiyanl[ldbnokfmyoma] == (hrllkahyojud&0x0f)) { kuisskbiyanl[bloapqemhdha] = ytlcwydutkha;
} } else if ((ldbnokfmyoma < 8) && (bloapqemhdha < 4)) { ldbnokfmyoma -= 4;
if (kuisskbiyanl[ldbnokfmyoma] < (hrllkahyojud&0x0f)) { kuisskbiyanl[bloapqemhdha] = ytlcwydutkha;
} } else if ((ldbnokfmyoma < 12) && (bloapqemhdha < 4)) { ldbnokfmyoma -= 8;
if (kuisskbiyanl[ldbnokfmyoma] > (hrllkahyojud&0x0f)) { kuisskbiyanl[bloapqemhdha] = ytlcwydutkha;
} } } static bool rvmcyfiwdyey(uint8_t nhxxzxrljjtk, const bc7215DataVarPkt_t* dataPktCool25C) { uint16_t zwkeegcjawso;
uint16_t zmhpcahvuugt;
const bc7215FormatPkt_t* fmt = NULL;
envgkvyuvctc = NULL;
domyebqqxybm = false;
lyoruyqupvgk = false;
if ((dataPktCool25C != NULL) && !(nhxxzxrljjtk&0x80)) { if (dataPktCool25C->bitLen == 0) { fmt = ((const bc7215CombinedMsg_t*)dataPktCool25C)->body.msg.fmt;
if (fmt != NULL) { pivgeeqvhhpr = *fmt;
domyebqqxybm = true;
} dataPktCool25C = ((const bc7215CombinedMsg_t*)dataPktCool25C)->body.msg.datPkt;
if ((fmt == NULL) || (dataPktCool25C == NULL)) { return false;
} } if ((dataPktCool25C->bitLen <= BC7215_MAX_RX_DATA_SIZE*8) && (dataPktCool25C->bitLen > 0)) { tjmnkrnjmplx = nhxxzxrljjtk;
sapcqlhnefas.bitLen = dataPktCool25C->bitLen;
zmhpcahvuugt = (sapcqlhnefas.bitLen+7)/8;
memcpy(sapcqlhnefas.data, dataPktCool25C->data, zmhpcahvuugt);
wiznxuyrkzhr = -1;
for (zwkeegcjawso=0; zwkeegcjawso<saxoggodtxyn; zwkeegcjawso++) {
if (mzizjkxcdqfk(zwkeegcjawso)) { wiznxuyrkzhr = zwkeegcjawso;
vbsdeujddnxr = false;
if ( !envgkvyuvctc->spec.meugerfooagb && wefxmuqqkamb(&envgkvyuvctc->tbqxbwmytmil.buhyvlrkmues.oeiaiwqhculr, zyydpgxliaif) && wefxmuqqkamb(&envgkvyuvctc->tbqxbwmytmil.buhyvlrkmues.cuoycwtsmtjr, zyydpgxliaif) ) { vbsdeujddnxr = true;
} return true;
} } } } return false;
} static bool aoaftjjpqlti(uint8_t uzqwwdupgciv, const bc7215CombinedMsg_t luuqccowyelx[], uint8_t mchwqpdisqxx) { uint8_t pfyxigjvuivq;
envgkvyuvctc = NULL;
if ((uzqwwdupgciv > 0) && ((uzqwwdupgciv&0x3f) <= 4) && (luuqccowyelx != NULL) && (luuqccowyelx[0].body.msg.fmt != NULL)) { pivgeeqvhhpr = *luuqccowyelx[0].body.msg.fmt;
if (bkmlskoanlff(luuqccowyelx[0].body.msg.datPkt->bitLen, uzqwwdupgciv&0x3f, mchwqpdisqxx) && luqxfomtfrfm(uzqwwdupgciv&0x3f, luuqccowyelx)) { pfyxigjvuivq = pivgeeqvhhpr.signature.bits.sig | (uzqwwdupgciv&0x40);
return rvmcyfiwdyey(pfyxigjvuivq, (const bc7215DataVarPkt_t*)&ziciuqwubgaa);
} } return false;
} static const bc7215DataVarPkt_t* zzezbpbxzbmm(int8_t debjxhlfkvfh, int8_t ywvzvqclkjuo, int8_t nzawprzzlfmj, int8_t rumsintiplya) { bool wbuhqlajenqp;
uint8_t hymesdhmcvtn;
uint8_t ebfzpamjfkmf;
const struct jzrjinarvghn* gksqodroosce;
wbuhqlajenqp = false;
gksqodroosce = envgkvyuvctc;
if ((rumsintiplya == KEY_MODE) && (envgkvyuvctc->zagbhfvgdmex.mopbcjzgmcja&0x20)) { envgkvyuvctc = &((const struct mnbpqhzlmcjq*)envgkvyuvctc->zagbhfvgdmex.ytlcwydutkha)->mfziljnihjsa;
wbuhqlajenqp = true;
} else if (((rumsintiplya == KEY_PLUS) || (rumsintiplya == KEY_MINUS)) && (envgkvyuvctc->lkytgmwsvbjc.mopbcjzgmcja&0x20)) { envgkvyuvctc = &((const struct mnbpqhzlmcjq*)envgkvyuvctc->lkytgmwsvbjc.ytlcwydutkha)->mfziljnihjsa;
wbuhqlajenqp = true;
} else if ((rumsintiplya == KEY_FAN) && (envgkvyuvctc->efzkaswlxsjp.mopbcjzgmcja&0x20)) { envgkvyuvctc = &((const struct mnbpqhzlmcjq*)envgkvyuvctc->efzkaswlxsjp.ytlcwydutkha)->mfziljnihjsa;
wbuhqlajenqp = true;
} if (wbuhqlajenqp) { kjqjwbcmhzpv = sapcqlhnefas;
if (!bc7215_ac_replace_base(mhiohwhuizkc, (const bc7215DataVarPkt_t*)&wqwpsggznumr)) { return NULL;
} } kuisskbiyanl[0] = debjxhlfkvfh;
kuisskbiyanl[1] = ywvzvqclkjuo;
kuisskbiyanl[2] = nzawprzzlfmj;
kuisskbiyanl[3] = rumsintiplya;
if (envgkvyuvctc != NULL) { if (!envgkvyuvctc->spec.duydkrzywxnm) { hymesdhmcvtn = envgkvyuvctc->lbtdeitxhjhh->set.tgrplbauzqqq;
ebfzpamjfkmf = envgkvyuvctc->lbtdeitxhjhh->set.keodtzzroqbd;
wjiomkhdaafv(hymesdhmcvtn, ebfzpamjfkmf);
hymesdhmcvtn = envgkvyuvctc->lbtdeitxhjhh->set.okquusoiarbp;
ebfzpamjfkmf = envgkvyuvctc->lbtdeitxhjhh->set.mzgkhzfchxtc;
wjiomkhdaafv(hymesdhmcvtn, ebfzpamjfkmf);
hymesdhmcvtn = envgkvyuvctc->lbtdeitxhjhh->set.pkpooopfmkrs;
ebfzpamjfkmf = envgkvyuvctc->lbtdeitxhjhh->set.fcvaxtjopotg;
wjiomkhdaafv(hymesdhmcvtn, ebfzpamjfkmf);
} ykfwzrfuvamm[0] = 0;
ykfwzrfuvamm[1] = 0;
ykfwzrfuvamm[2] = 0;
ykfwzrfuvamm[3] = 0;
if (kuisskbiyanl[0] >= 0) { ykfwzrfuvamm[0] = aquknpkkmtpz(&envgkvyuvctc->lkytgmwsvbjc, kuisskbiyanl[0], vcabqkuncaai);
} if ((kuisskbiyanl[1] >= 0) && (kuisskbiyanl[1]<0x0f)) { ykfwzrfuvamm[1] = aquknpkkmtpz(&envgkvyuvctc->zagbhfvgdmex, kuisskbiyanl[1], vcabqkuncaai);
if (envgkvyuvctc->zagbhfvgdmex.mopbcjzgmcja & 0x80) { kuisskbiyanl[3] = kuisskbiyanl[1];
} } if ((kuisskbiyanl[2] >= 0) && (kuisskbiyanl[2] < 0x0f)) { ykfwzrfuvamm[2] = aquknpkkmtpz(&envgkvyuvctc->efzkaswlxsjp, kuisskbiyanl[2], vcabqkuncaai);
if (envgkvyuvctc->efzkaswlxsjp.mopbcjzgmcja & 0x80) { kuisskbiyanl[3] = kuisskbiyanl[2];
} } if ((kuisskbiyanl[3] >= 0) && (kuisskbiyanl[3]<0x0f)) { ykfwzrfuvamm[3] = aquknpkkmtpz(&envgkvyuvctc->jyzhocqchyzz, kuisskbiyanl[3], vcabqkuncaai);
} if (envgkvyuvctc->lbtdeitxhjhh->set.nyqmexqqqjzu != NULL) { pkynntmaadci(envgkvyuvctc);
} enbovseslkvh(envgkvyuvctc, vcabqkuncaai);
awsteilqqidy(envgkvyuvctc);
drrrdscymaou(envgkvyuvctc);
if (wbuhqlajenqp) { envgkvyuvctc = gksqodroosce;
if (!bc7215_ac_replace_base(tjmnkrnjmplx, (const bc7215DataVarPkt_t*)&kjqjwbcmhzpv)) { return NULL;
} if (lyoruyqupvgk) { qanfaymkryfx.body.msg.fmt = &iaketlgrgirb;
qanfaymkryfx.body.msg.datPkt = (bc7215DataVarPkt_t*)&ziciuqwubgaa;
return (const bc7215DataVarPkt_t*)&qanfaymkryfx;
} } if (tyxuvftnzciv) { qanfaymkryfx.body.msg.fmt = &pivgeeqvhhpr;
qanfaymkryfx.body.msg.datPkt = (bc7215DataVarPkt_t*)&ziciuqwubgaa;
return (const bc7215DataVarPkt_t*)&qanfaymkryfx;
} else { return (const bc7215DataVarPkt_t*)&ziciuqwubgaa;
} } else { return  NULL;
} } static bool cobiupqigoqa(const bc7215DataVarPkt_t* bvyweglqjedh) { const uint8_t* yrxfiihydwpf;
uint16_t	bitLen;
struct hupxupixhngz buhyvlrkmues;
yrxfiihydwpf = (const uint8_t*)envgkvyuvctc->tbqxbwmytmil.bvyweglqjedh;
bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
if (bitLen == 0) { yrxfiihydwpf += 2+33;
} bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
yrxfiihydwpf += (bitLen+7)/8 + 2;
bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
if (bitLen != 0) { yrxfiihydwpf += (bitLen+7)/8 + 2;
} else { yrxfiihydwpf += 2;
} buhyvlrkmues.uzmxwkhdlkjl = *yrxfiihydwpf;
buhyvlrkmues.kuaqjbcvpyes = *(yrxfiihydwpf+1);
buhyvlrkmues.bits = *(yrxfiihydwpf+2);
if ( bvyweglqjedh->data[buhyvlrkmues.kuaqjbcvpyes] == psrggqspjmka[buhyvlrkmues.uzmxwkhdlkjl](bvyweglqjedh->data[buhyvlrkmues.kuaqjbcvpyes], buhyvlrkmues.bits) ) { return true;
} else { return false;
} } const char* bc7215_ac_get_ver(void) { return VERSION;
} bool bc7215_ac_init(uint8_t nhxxzxrljjtk, const bc7215DataVarPkt_t* dataPktCool25C) { pfipaetctpwp = false;
return rvmcyfiwdyey(nhxxzxrljjtk, dataPktCool25C);
} bool bc7215_ac_init_f(uint8_t nhxxzxrljjtk, const bc7215DataVarPkt_t* bsstpbtqzntf) { pfipaetctpwp = true;
return rvmcyfiwdyey(nhxxzxrljjtk, bsstpbtqzntf);
} bool bc7215_ac_init2(uint8_t uzqwwdupgciv, const bc7215CombinedMsg_t luuqccowyelx[], uint8_t mchwqpdisqxx) { pfipaetctpwp = false;
return aoaftjjpqlti(uzqwwdupgciv, luuqccowyelx, mchwqpdisqxx);
} bool bc7215_ac_init2_f(uint8_t uzqwwdupgciv, const bc7215CombinedMsg_t luuqccowyelx[], uint8_t mchwqpdisqxx) { pfipaetctpwp = true;
return aoaftjjpqlti(uzqwwdupgciv, luuqccowyelx, mchwqpdisqxx);
} bool bc7215_ac_find_next(void) { uint16_t zwkeegcjawso;
if (wiznxuyrkzhr >= 0) { if (tyxuvftnzciv) { habgxxtwlylz();
tyxuvftnzciv = false;
}
#ifndef _NO_DEPRECATED
else if (((envgkvyuvctc->jyzhocqchyzz.mopbcjzgmcja&0xf0) == 0x80) && domyebqqxybm) { yebwpscaeong(envgkvyuvctc);
return true;
} else if ((envgkvyuvctc->jyzhocqchyzz.mopbcjzgmcja&0xf0) == 0xe0) { tyxuvftnzciv = true;
return true;
}
#endif
for (zwkeegcjawso=wiznxuyrkzhr+1; zwkeegcjawso<saxoggodtxyn; zwkeegcjawso++)
{ if (mzizjkxcdqfk(zwkeegcjawso)) { wiznxuyrkzhr = zwkeegcjawso;
return true;
} } } wiznxuyrkzhr = -1;
envgkvyuvctc = NULL;
return false;
} const bc7215DataVarPkt_t* bc7215_ac_set(int8_t ugqvbvsaehvc, int8_t ywvzvqclkjuo, int8_t nzawprzzlfmj, int8_t rumsintiplya) { if (ugqvbvsaehvc > 14) { ugqvbvsaehvc = -1;
} if (ywvzvqclkjuo > MODE_FAN) { ywvzvqclkjuo = -1;
} if (nzawprzzlfmj > FAN_HIGH) { nzawprzzlfmj = -1;
} if (rumsintiplya > KEY_FAN) { rumsintiplya = -1;
} return zzezbpbxzbmm(ugqvbvsaehvc, ywvzvqclkjuo, nzawprzzlfmj, rumsintiplya);
} const bc7215DataVarPkt_t* bc7215_ac_set_f(int8_t oslsllbntxul, int8_t ywvzvqclkjuo, int8_t nzawprzzlfmj, int8_t rumsintiplya) { uint8_t	ugqvbvsaehvc;
if (ywvzvqclkjuo > MODE_FAN) { ywvzvqclkjuo = -1;
} if (nzawprzzlfmj > FAN_HIGH) { nzawprzzlfmj = -1;
} if (rumsintiplya > KEY_FAN) { rumsintiplya = -1;
} if ((oslsllbntxul < 0) || (oslsllbntxul > 28)) { ugqvbvsaehvc = -1;
} else { if (envgkvyuvctc->fihqcdjkaqjh != NULL) { ugqvbvsaehvc = envgkvyuvctc->fihqcdjkaqjh->iezimrbuhymx[oslsllbntxul];
nchrmzxsrkgy(&envgkvyuvctc->fihqcdjkaqjh->wwoykbnvyqzp, oslsllbntxul, vcabqkuncaai);
} else { ugqvbvsaehvc = dirhnlinsrls.iezimrbuhymx[oslsllbntxul];
} } return zzezbpbxzbmm(ugqvbvsaehvc, ywvzvqclkjuo, nzawprzzlfmj, rumsintiplya);
} const bc7215DataVarPkt_t* bc7215_ac_on(void) { uint16_t qxvjjgdwfbny;
const uint8_t*	yrxfiihydwpf;
if (wiznxuyrkzhr >= 0) { if (envgkvyuvctc->spec.meugerfooagb) { yrxfiihydwpf = (const uint8_t*)envgkvyuvctc->tbqxbwmytmil.bvyweglqjedh;
jzrbzxjvujig.bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
if (jzrbzxjvujig.bitLen != 0) { qxvjjgdwfbny = (jzrbzxjvujig.bitLen+7)/8+2;
yrxfiihydwpf = yrxfiihydwpf+qxvjjgdwfbny;
if ((*yrxfiihydwpf != 0) || (*(yrxfiihydwpf+1) != 0)) { jzrbzxjvujig.bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
memcpy(&jzrbzxjvujig.data, yrxfiihydwpf+2, (jzrbzxjvujig.bitLen+7)/8);
if (tyxuvftnzciv) { qanfaymkryfx.bitLen = 0;
qanfaymkryfx.body.msg.fmt = &pivgeeqvhhpr;
qanfaymkryfx.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&jzrbzxjvujig);
return (const bc7215DataVarPkt_t*)&qanfaymkryfx;
} else { return (const bc7215DataVarPkt_t*)(&jzrbzxjvujig);
} } } else { yrxfiihydwpf += 2;
memcpy(&xcjltbzvwjof, yrxfiihydwpf, 33);
yrxfiihydwpf += 33;
jzrbzxjvujig.bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
qxvjjgdwfbny = (jzrbzxjvujig.bitLen+7)/8+2;
yrxfiihydwpf += qxvjjgdwfbny;
jzrbzxjvujig.bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
if (jzrbzxjvujig.bitLen != 0) { memcpy(&jzrbzxjvujig.data, yrxfiihydwpf+2, (jzrbzxjvujig.bitLen+7)/8);
qanfaymkryfx.bitLen = 0;
qanfaymkryfx.body.msg.fmt = &xcjltbzvwjof;
qanfaymkryfx.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&jzrbzxjvujig);
return (const bc7215DataVarPkt_t*)&qanfaymkryfx;
} } } else if (envgkvyuvctc->spec.jkzmicqrmkcx || (!((envgkvyuvctc->lkytgmwsvbjc.mopbcjzgmcja | envgkvyuvctc->zagbhfvgdmex.mopbcjzgmcja | envgkvyuvctc->efzkaswlxsjp.mopbcjzgmcja)&0x80) && (envgkvyuvctc->jyzhocqchyzz.ytlcwydutkha != NULL))) { return iwtxccugqtjo(5);
} } return NULL;
} const bc7215DataVarPkt_t* bc7215_ac_off(void) { const uint8_t*	yrxfiihydwpf;
if (wiznxuyrkzhr >= 0) { if (!envgkvyuvctc->spec.meugerfooagb) { return iwtxccugqtjo(4);
} else { yrxfiihydwpf = (const uint8_t*)envgkvyuvctc->tbqxbwmytmil.bvyweglqjedh;
jzrbzxjvujig.bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
if (jzrbzxjvujig.bitLen != 0) { memcpy(&jzrbzxjvujig.data, yrxfiihydwpf+2, (jzrbzxjvujig.bitLen+7)/8);
if (tyxuvftnzciv) { qanfaymkryfx.bitLen = 0;
qanfaymkryfx.body.msg.fmt = &pivgeeqvhhpr;
qanfaymkryfx.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&jzrbzxjvujig);
return (const bc7215DataVarPkt_t*)&qanfaymkryfx;
} else { return (const bc7215DataVarPkt_t*)(&jzrbzxjvujig);
} } else { yrxfiihydwpf += 2;
memcpy(&xcjltbzvwjof, yrxfiihydwpf, 33);
yrxfiihydwpf += 33;
jzrbzxjvujig.bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
memcpy(&jzrbzxjvujig.data, yrxfiihydwpf+2, (jzrbzxjvujig.bitLen+7)/8);
if (jzrbzxjvujig.bitLen != 0) { qanfaymkryfx.bitLen = 0;
qanfaymkryfx.body.msg.fmt = &xcjltbzvwjof;
qanfaymkryfx.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&jzrbzxjvujig);
return (const bc7215DataVarPkt_t*)&qanfaymkryfx;
} } } } return NULL;
} uint8_t bc7215_ac_predefined_cnt(void) { return ctsqslxbogzy;
} const bc7215DataVarPkt_t* bc7215_ac_predefined_data(uint8_t quuhtldgsphz) { const uint8_t* yrxfiihydwpf;
if (quuhtldgsphz < ctsqslxbogzy) { yrxfiihydwpf = (const uint8_t*)ecmxlmscqqko[quuhtldgsphz];
jzrbzxjvujig.bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
memcpy(&jzrbzxjvujig.data, yrxfiihydwpf+2, (jzrbzxjvujig.bitLen+7)/8);
return (const bc7215DataVarPkt_t*)&jzrbzxjvujig;
} else { return NULL;
} } const bc7215DataVarPkt_t* bc7215_ac_predefined_data_f(uint8_t quuhtldgsphz) { const uint8_t* yrxfiihydwpf;
if (quuhtldgsphz < ctsqslxbogzy) { yrxfiihydwpf = (const uint8_t*)soccmyicelnf[quuhtldgsphz];
jzrbzxjvujig.bitLen = ((*(yrxfiihydwpf+1))<<8)+*yrxfiihydwpf;
memcpy(&jzrbzxjvujig.data, yrxfiihydwpf+2, (jzrbzxjvujig.bitLen+7)/8);
return (const bc7215DataVarPkt_t*)&jzrbzxjvujig;
} else { return NULL;
} } const bc7215FormatPkt_t* bc7215_ac_predefined_fmt(uint8_t quuhtldgsphz) { if (quuhtldgsphz < ctsqslxbogzy) { memcpy(&xcjltbzvwjof, ((const uint8_t*)&zkzcieglrfln)+33*quuhtldgsphz, 33);
return &xcjltbzvwjof;
} else { return NULL;
} } const char* bc7215_ac_predefined_name(uint8_t quuhtldgsphz) { if (quuhtldgsphz < ctsqslxbogzy) { return welxgepyuvqg[quuhtldgsphz];
} else { return "";
} }
#ifndef _NO_DEPRECATED
uint8_t bc7215_ac_need_extra_sample(void) { uint8_t vmjindlfsbxu;
vmjindlfsbxu = 0;
if (envgkvyuvctc != NULL) { if (envgkvyuvctc->lkytgmwsvbjc.mopbcjzgmcja&0x20) { vmjindlfsbxu = 1;
} if (envgkvyuvctc->zagbhfvgdmex.mopbcjzgmcja&0x20) { vmjindlfsbxu = 2;
} if (envgkvyuvctc->efzkaswlxsjp.mopbcjzgmcja&0x20) { vmjindlfsbxu = 3;
} if (((envgkvyuvctc->jyzhocqchyzz.mopbcjzgmcja&0xf0) == 0xc0) ||(tyxuvftnzciv && ((envgkvyuvctc->jyzhocqchyzz.mopbcjzgmcja&0xf0) == 0xe0))) { vmjindlfsbxu = 4;
} } return vmjindlfsbxu;
} bool bc7215_ac_save_2nd_base(uint8_t nhxxzxrljjtk, const bc7215CombinedMsg_t* message) { uint8_t zmhpcahvuugt;
if (!(nhxxzxrljjtk&0x80) && (message != NULL) && (message->body.msg.fmt->signature.bits.sig == (nhxxzxrljjtk&0x3f))) { zmhpcahvuugt = (message->body.msg.datPkt->bitLen+7)/8;
if (zmhpcahvuugt <= BC7215_MAX_RX_DATA_SIZE) { iaketlgrgirb = *message->body.msg.fmt;
lyoruyqupvgk = true;
mhiohwhuizkc = nhxxzxrljjtk;
wqwpsggznumr.bitLen = message->body.msg.datPkt->bitLen;
memcpy(wqwpsggznumr.data, message->body.msg.datPkt->data, zmhpcahvuugt);
return true;
} } return false;
} bc7215CombinedMsg_t bc7215_ac_get_2nd_base(void) { bc7215CombinedMsg_t zcmmbhdnqzew;
zcmmbhdnqzew.bitLen = 0;
zcmmbhdnqzew.body.msg.datPkt = (bc7215DataVarPkt_t*)&wqwpsggznumr;
zcmmbhdnqzew.body.msg.fmt = &iaketlgrgirb;
return zcmmbhdnqzew;
}
#endif
bool bc7215_ac_replace_base(uint8_t nhxxzxrljjtk, const bc7215DataVarPkt_t* ugsffuryncdl) { uint8_t zmhpcahvuugt;
uint8_t zdhdyorfancc;
if ((envgkvyuvctc != NULL) && (ugsffuryncdl != NULL) && (ugsffuryncdl->bitLen <= BC7215_MAX_RX_DATA_SIZE*8)) { if (ugsffuryncdl->bitLen != 0) { if (!(nhxxzxrljjtk&0x80)) { zmhpcahvuugt = (ugsffuryncdl->bitLen+7)/8;
if (ugsffuryncdl->bitLen == envgkvyuvctc->bitLen) { memcpy(sapcqlhnefas.data, ugsffuryncdl->data, zmhpcahvuugt);
tjmnkrnjmplx = nhxxzxrljjtk;
sapcqlhnefas.bitLen = ugsffuryncdl->bitLen;
} else { memcpy(ziciuqwubgaa.data, ugsffuryncdl->data, zmhpcahvuugt);
ziciuqwubgaa.bitLen = ugsffuryncdl->bitLen;
ldyzjyfsozom = true;
return false;
} } else { return false;
} } else if ((nhxxzxrljjtk&0x3f) < 4) { zdhdyorfancc = nhxxzxrljjtk&0x40;
if (luqxfomtfrfm(nhxxzxrljjtk&0x3f, (const bc7215CombinedMsg_t*) ugsffuryncdl)) { if (ziciuqwubgaa.bitLen == envgkvyuvctc->bitLen) { tjmnkrnjmplx = pivgeeqvhhpr.signature.bits.sig | zdhdyorfancc;
sapcqlhnefas = ziciuqwubgaa;
} else { ldyzjyfsozom = true;
return false;
} } else { return false;
} } else { return false;
} ldyzjyfsozom = false;
qgcqefcklmta(envgkvyuvctc, tjmnkrnjmplx, (const bc7215DataVarPkt_t*)&sapcqlhnefas);
if (enbovseslkvh(envgkvyuvctc, zyydpgxliaif)) { return true;
} return false;
} else { return false;
} } const bc7215FormatPkt_t* bc7215_ac_get_base_fmt(void) { return &pivgeeqvhhpr;
} const bc7215DataVarPkt_t* bc7215_ac_get_base_data(void) { return (bc7215DataVarPkt_t*)&sapcqlhnefas;
} uint8_t bc7215_ac_get_base_status(void) { return tjmnkrnjmplx;
} bool bc7215_ac_parse(int8_t* debjxhlfkvfh, int8_t* ywvzvqclkjuo, int8_t* nzawprzzlfmj, int8_t* loraolwfesru) { uint16_t	saxtghqpmdlu=0;
uint16_t	cywpppiwvowx=0;
const bc7215DataVarPkt_t*	hloudcurtwah;
bool vmjindlfsbxu = false;
*debjxhlfkvfh = -1;
*ywvzvqclkjuo = -1;
*nzawprzzlfmj = -1;
*loraolwfesru = -1;
if (!ldyzjyfsozom) { vmjindlfsbxu = enbovseslkvh(envgkvyuvctc, zyydpgxliaif);
if (vmjindlfsbxu) { *debjxhlfkvfh = iqvyumnaknul(&envgkvyuvctc->lkytgmwsvbjc, 15);
*ywvzvqclkjuo = iqvyumnaknul(&envgkvyuvctc->zagbhfvgdmex, 5);
*nzawprzzlfmj = iqvyumnaknul(&envgkvyuvctc->efzkaswlxsjp, 4);
*loraolwfesru = hhhchexgkldv(envgkvyuvctc);
} } else { if (envgkvyuvctc->spec.meugerfooagb) { hloudcurtwah = bc7215_ac_off();
if (hloudcurtwah != NULL) { if (hloudcurtwah->bitLen != 0) { cywpppiwvowx = hloudcurtwah->bitLen;
} else { cywpppiwvowx = ((const bc7215CombinedMsg_t*)hloudcurtwah)->body.msg.datPkt->bitLen;
} } hloudcurtwah = bc7215_ac_on();
if (hloudcurtwah != NULL) { if (hloudcurtwah->bitLen != 0) { saxtghqpmdlu = hloudcurtwah->bitLen;
} else { saxtghqpmdlu = ((const bc7215CombinedMsg_t*)hloudcurtwah)->body.msg.datPkt->bitLen;
} } if (cywpppiwvowx == ziciuqwubgaa.bitLen) { vmjindlfsbxu = true;
if (envgkvyuvctc->spec.jkzmicqrmkcx) { *loraolwfesru = 2;
} else if (saxtghqpmdlu != cywpppiwvowx) { *loraolwfesru = 0;
} else if (cobiupqigoqa((bc7215DataVarPkt_t*)&ziciuqwubgaa)) { *loraolwfesru = 0;
} else { *loraolwfesru = 1;
} } else if (saxtghqpmdlu == ziciuqwubgaa.bitLen) { vmjindlfsbxu = true;
*loraolwfesru = 1;
} } } return vmjindlfsbxu;
} bool bc7215_ac_parse_f(int8_t* oslsllbntxul, int8_t* ywvzvqclkjuo, int8_t* nzawprzzlfmj, int8_t* loraolwfesru) { bool vmjindlfsbxu;
vmjindlfsbxu = bc7215_ac_parse(oslsllbntxul, ywvzvqclkjuo, nzawprzzlfmj, loraolwfesru);
if (vmjindlfsbxu && (*oslsllbntxul >= 0)) { if (envgkvyuvctc->fihqcdjkaqjh != NULL) { *oslsllbntxul = ljjyonmpujjk(envgkvyuvctc->fihqcdjkaqjh);
} else { *oslsllbntxul = ljjyonmpujjk(&dirhnlinsrls);
} } return vmjindlfsbxu;
}
