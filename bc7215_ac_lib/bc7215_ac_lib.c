#include "bc7215_ac_lib.h"
#include <string.h>
#define dblsytetyfke  0
#define scdmdvhoqlof   1
struct kdjigrgqrois;
struct rkmkqkradcrt;
struct odxfhxsrevig;
struct sgqtcddyvqhi;
struct lygcleobgeet;
union idfrrqsectwd;
static void vwvzidbltkov(const struct odxfhxsrevig* kgfvcoakbkgf);
static void cycwqtmggord(const struct kdjigrgqrois* shzveqsbwpgu);
static void fefldogauyki(const struct kdjigrgqrois* shzveqsbwpgu);
static void hvmacthavfnw(uint8_t jxctryevobrs[][BC7215_MAX_RX_DATA_SIZE], bc7215DataVarPkt_t* vxvmexsmwrru, const struct kdjigrgqrois* shzveqsbwpgu);
static void iwsmbpihijwx(const struct kdjigrgqrois* shzveqsbwpgu);
static uint8_t ijzgtrlowffo(uint8_t byte);
static void hdewbzptlbih(const struct kdjigrgqrois* shzveqsbwpgu, bc7215DataVarPkt_t* vxvmexsmwrru);
static bool lcvfbnqxzxid(const bc7215DataVarPkt_t* npikivgkyypz);
static bc7215DataMaxPkt_t	vyudfzxzxuqv;
static bc7215DataMaxPkt_t	zloiimuniybf;
static bc7215DataMaxPkt_t	qlavfhidhmdq;
static bc7215DataMaxPkt_t	mkrbbjgfiafa;
static bc7215DataMaxPkt_t	vfjfcbtuqghr;
static bc7215FormatPkt_t	jadyfbnomgtt;
static bc7215FormatPkt_t   bmmyftuypsva;
static bc7215FormatPkt_t   bzvflvgyviul;
static bc7215FormatPkt_t	hsygtmafbtdx;
static uint8_t sxsgupbcixzv[4][BC7215_MAX_RX_DATA_SIZE];
static uint8_t nvhiozlktdhn[4][BC7215_MAX_RX_DATA_SIZE];
static int16_t tvpnkcpbdlod = -1;
static uint8_t qobvowrftgaq;
static uint8_t rcmwutmxcidu;
static uint8_t jedhoqnrupdm;
static struct odxfhxsrevig* mqhiridcenhi;
static uint8_t wvephcqvrhxl[4];
static int8_t ragsgmpbksry[4];
static bc7215CombinedMsg_t xlvdqneiksch = {0,{.msg={.fmt=NULL, .datPkt=NULL}}};
static const struct kdjigrgqrois* eshuyivywcyl;
static bool yvufzzwbxjjd;
static bool ekvawgrcfycz;
static bool uohaukzjobju;
static bool fpecgvzrimrg = false;
static bool pcybytxdfact;
static bool wqvxbiaheaem;
static uint8_t hxeevvisyxvd = 25;
static uint8_t vbhticufdmxg = 78;
int msg, pnum;
static const uint8_t gigfcrhtxgdj[8] = { 0xff, 0x01, 0x03, 0x07, 0x0f, 0x1f, 0x3f, 0x7f };
static const uint8_t aznxoegkdurg[8] = { 0xff, 0x80, 0xc0, 0xe0, 0xf0, 0xf8, 0xfc, 0xfe };
static const uint8_t bmjzspwldmxy[4] = { 0x03, 0x0c, 0x30, 0xc0 };
static const uint8_t kdcrfwgoywrj[8] = { 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80 };
static const uint8_t ukdrdbpzsusv[16] = { 0x00, 0x02, 0x01, 0x03, 0x08, 0x0a, 0x09, 0x0b, 0x04, 0x06, 0x05, 0x07, 0x0c, 0x0e, 0x0d, 0x0f };
static const uint8_t aatxfupsmyuf[16] = { 0, 0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07, 0x0f };
static const uint8_t tilsjbkcekcb[16] = { 0, 0x01, 0x01, 0x02, 0x01, 0x02, 0x02, 0x03, 0x01, 0x02, 0x02, 0x03, 0x02, 0x03, 0x03, 0x04 };
typedef struct sgqtcddyvqhi { uint8_t		lxnfhtpgqfci;
uint8_t		mvclhuiimujy;
uint8_t		lyjelnqjwcpn;
uint8_t		iqvisgvmqmhd;
const uint8_t*	ovxhljuweifs;
} sgqtcddyvqhi;
typedef struct lygcleobgeet { uint8_t     oesqxabczxwe;
uint8_t     lxnfhtpgqfci;
uint8_t     mvclhuiimujy;
uint8_t     lyjelnqjwcpn;
const uint8_t*    ulllwrirovmo;
} lygcleobgeet;
typedef union idfrrqsectwd { struct { uint8_t		tfdslecfsyog;
uint8_t		jbfskexyzrhn;
uint8_t		hfvkajvenbnh;
uint8_t		lsgevcqemhdh;
uint8_t		mfuegtfdfyhd;
uint8_t		snygvnvbkdmu;
const lygcleobgeet*  vrdfzsmcauwh;
} set;
struct { uint8_t		hngolhghqowm;
uint8_t		jwpajwdilkuh;
uint8_t		msoqccwsovjs;
uint8_t		dbcrfmkicojr;
} nshlnwwdnxmh;
} idfrrqsectwd;
#ifndef _NO_DEPRECATED
struct icejugalibdt { const lygcleobgeet*		yfesjtznxtiz;
const struct kdjigrgqrois*	shzveqsbwpgu;
uint8_t 	pvxhudwfwylc;
uint8_t		nnrzkzuvzcbl;
};
#endif
struct ekojtdrzppcn { uint8_t		yfzeivmnnrai;
uint8_t 	mvclhuiimujy;
uint8_t		bits;
};
struct vpdearhvdwqb { struct { uint8_t	   uzajmeiqozpf : 4;
uint8_t		yfzeivmnnrai : 4;
} jxctryevobrs;
uint8_t 	mvclhuiimujy;
uint8_t		bits;
};
typedef void (*setExtBase_t)(const bc7215DataVarPkt_t* , const bc7215FormatPkt_t*);
union offBits_t { struct { struct vpdearhvdwqb  dntwwzvcqjni;
struct vpdearhvdwqb  jpelfzaadwso;
} tfdvcvkctfsw;
const bc7215DataVarPkt_t* npikivgkyypz;
const bc7215CombinedMsg_t*      qlnmbonxxkff;
const setExtBase_t		gvgpztzhmfxl;
};
struct odxfhxsrevig { uint8_t		ncudadtiieiw;
uint8_t		kjdtvsdspmqy;
int8_t		hvqubynhawbz;
uint8_t		nedpotigczcm;
struct { uint8_t		yfzeivmnnrai : 5;
uint8_t    dizzshmncdny : 1;
uint8_t		byte : 1;
uint8_t     cwreubgjosza  : 1;
} yfzeivmnnrai;
int8_t		odhazyjtfxnx;
int8_t		uegiyqtqayhs;
uint8_t		qnnibacbltlo;
uint8_t		qpvvigyfqwqu;
};
typedef bool (*algorithm_t)(const struct kdjigrgqrois* shzveqsbwpgu, const struct odxfhxsrevig* kgfvcoakbkgf, bool xmtdckoioaxx);
struct rkmkqkradcrt { algorithm_t zwvhuwtjrnho;
const struct odxfhxsrevig* kgfvcoakbkgf;
};
struct yibohltnjvlz { const int8_t*	aejqufrcwkkq;
sgqtcddyvqhi			xlfohizjsfwi;
};
struct kdjigrgqrois { struct { uint8_t ahtyzigcwkfz  : 1;
uint8_t xcukretehlgd : 1;
uint8_t    uwhisdczmgip : 1;
uint8_t      puvjpxepuxnx : 1;
uint8_t  lkpnrrvrqsdm : 1;
uint8_t lrobawqzqmff : 1;
uint8_t  gerxujbjmtkf : 1;
} spec;
uint8_t  signature;
uint16_t bitLen;
uint16_t nshlnwwdnxmh[4];
sgqtcddyvqhi  dehqyzmoyahd;
sgqtcddyvqhi  fgstngnlzpzg;
sgqtcddyvqhi  kheyzdjrjuew;
sgqtcddyvqhi  bgofcjmacpch;
const idfrrqsectwd*  uuipfhjicnzd;
union offBits_t	vdjdiohbbbln;
const struct rkmkqkradcrt* afnuksvbkbvr;
const struct yibohltnjvlz*	cjxibzuelnnx;
};
struct aaqxyrxbybvu { struct kdjigrgqrois	shzveqsbwpgu;
const void* 				yfesjtznxtiz;
};
static uint8_t ijzgtrlowffo(uint8_t byte);
static void jicxmagmqots(const struct kdjigrgqrois* shzveqsbwpgu);
static bool mlauusswuxrq(const struct kdjigrgqrois* shzveqsbwpgu);
static uint8_t imujawtcyipt(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return jcihqccvysei+zdtizrjftpni;
} static uint8_t sxkrwflcmswc(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return jcihqccvysei^zdtizrjftpni;
} static uint8_t qbcbndszxqnn(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return jcihqccvysei&zdtizrjftpni;
} static uint8_t hdykwkdgmqkh(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return jcihqccvysei|zdtizrjftpni;
} static uint8_t nptnkprumxdx(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return zdtizrjftpni<<jcihqccvysei;
} static uint8_t quiwgnfjvqug(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return zdtizrjftpni>>jcihqccvysei;
} static uint8_t snesvmxvczzi(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return jcihqccvysei-zdtizrjftpni;
} static uint8_t jzqndxcuzkcn(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { uint8_t weiorwqmswxz = ((zdtizrjftpni&0x0f)+(zdtizrjftpni>>4))&0x0f;
if (weiorwqmswxz & 0x08) { weiorwqmswxz |= 0xf0;
} return jcihqccvysei+weiorwqmswxz;
} static uint8_t dgffrholzvfr(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { (void)jcihqccvysei;
return zdtizrjftpni;
} static uint8_t nsvzpclrecru(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return jcihqccvysei&(~zdtizrjftpni);
} static uint8_t iytznmvxamna (uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return ((jcihqccvysei&0xf0)+(zdtizrjftpni&0xf0)) | ((jcihqccvysei+zdtizrjftpni)&0x0f);
} static uint8_t jrgpyhqnwfzk(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return jcihqccvysei+ijzgtrlowffo(zdtizrjftpni);
} static uint8_t qmnrjrvgklrk(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return jcihqccvysei-ijzgtrlowffo(zdtizrjftpni);
} static uint8_t iyzrjvhpkkkp(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { return jcihqccvysei+tilsjbkcekcb[zdtizrjftpni>>4]+tilsjbkcekcb[zdtizrjftpni&0x0f];
} static uint8_t cggripcjvckt(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { (void)zdtizrjftpni;
return ~jcihqccvysei;
} static uint8_t borhaktbsvoe(uint8_t jcihqccvysei, uint8_t zdtizrjftpni) { (void)jcihqccvysei;
return (zdtizrjftpni<<4)|(zdtizrjftpni>>4);
} typedef uint8_t (*calFunc_t)(uint8_t, uint8_t);
static const calFunc_t scvmjwhwfhna[] = { imujawtcyipt, sxkrwflcmswc, qbcbndszxqnn, hdykwkdgmqkh, nptnkprumxdx, quiwgnfjvqug, snesvmxvczzi, jzqndxcuzkcn, dgffrholzvfr, nsvzpclrecru, iytznmvxamna, jrgpyhqnwfzk, qmnrjrvgklrk, iyzrjvhpkkkp, cggripcjvckt, borhaktbsvoe };
static uint8_t aqtdednzjrll(uint8_t jxctryevobrs, uint8_t mvclhuiimujy) { if (mvclhuiimujy&0x01) { return sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2]&0x0f;
} else { return sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2]>>4;
} } static void ocyrmoulkhow(uint8_t jxctryevobrs, uint8_t mvclhuiimujy, uint8_t data) { data &= 0x0f;
if (mvclhuiimujy&0x01) { sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2] = (sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2]&0xf0)|data;
} else { sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2] = (sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2]&0x0f) | (data<<4);
} } static uint8_t cgslostmrgck(uint8_t jxctryevobrs, uint8_t mvclhuiimujy) { if (mvclhuiimujy&0x01) { return sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2]>>4;
} else { return sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2]&0x0f;
} } static void wsbwmopcmcwu(uint8_t jxctryevobrs, uint8_t mvclhuiimujy, uint8_t data) { data &= 0x0f;
if (mvclhuiimujy&0x01) { sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2] = (sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2]&0x0f) | (data<<4);
} else { sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2] = (sxsgupbcixzv[jxctryevobrs][mvclhuiimujy/2]&0xf0)|data;
} } static bool fvectlrkjgcy(const struct kdjigrgqrois* shzveqsbwpgu, const struct odxfhxsrevig* kgfvcoakbkgf, bool xmtdckoioaxx) { uint8_t jxctryevobrs, emubljrywvpd, tizdudwljawi, nibStart, nibEnd;
uint8_t htodnioledof;
uint8_t jcihqccvysei, zdtizrjftpni;
uint8_t yiqmcmksqjww;
uint8_t odhazyjtfxnx, targetPos;
emubljrywvpd = kgfvcoakbkgf->ncudadtiieiw>>4;
tizdudwljawi = kgfvcoakbkgf->ncudadtiieiw&0x0f;
odhazyjtfxnx = kgfvcoakbkgf->odhazyjtfxnx&0x03;
jxctryevobrs = emubljrywvpd;
if (kgfvcoakbkgf->yfzeivmnnrai.dizzshmncdny) { yiqmcmksqjww = jedhoqnrupdm;
} else { yiqmcmksqjww = 0;
} while (jxctryevobrs <= tizdudwljawi) { if (jxctryevobrs == emubljrywvpd) { nibStart = kgfvcoakbkgf->kjdtvsdspmqy;
} else { nibStart = 0;
} if (jxctryevobrs == tizdudwljawi) { nibEnd = ((shzveqsbwpgu->nshlnwwdnxmh[jxctryevobrs]+7)/8)*2-1+kgfvcoakbkgf->hvqubynhawbz;
} else { nibEnd = ((shzveqsbwpgu->nshlnwwdnxmh[jxctryevobrs]+7)/8)*2-1;
} for (htodnioledof=nibStart; htodnioledof<=nibEnd; htodnioledof=htodnioledof+kgfvcoakbkgf->nedpotigczcm) {
zdtizrjftpni = aqtdednzjrll(jxctryevobrs, htodnioledof);
if (kgfvcoakbkgf->yfzeivmnnrai.cwreubgjosza) { jcihqccvysei = kgfvcoakbkgf->qpvvigyfqwqu;
targetPos = htodnioledof+kgfvcoakbkgf->uegiyqtqayhs;
yiqmcmksqjww = scvmjwhwfhna[kgfvcoakbkgf->yfzeivmnnrai.yfzeivmnnrai](jcihqccvysei, zdtizrjftpni);
yiqmcmksqjww &= kgfvcoakbkgf->qnnibacbltlo;
if (kgfvcoakbkgf->odhazyjtfxnx >= 0) { if (xmtdckoioaxx) { yiqmcmksqjww = (aqtdednzjrll(odhazyjtfxnx, targetPos)&(~kgfvcoakbkgf->qnnibacbltlo)) | yiqmcmksqjww;
ocyrmoulkhow(odhazyjtfxnx, targetPos, yiqmcmksqjww);
} else { if ((yiqmcmksqjww&0x0f) != (aqtdednzjrll(odhazyjtfxnx, targetPos)&(kgfvcoakbkgf->qnnibacbltlo))) { return false;
} } } } else { jcihqccvysei = yiqmcmksqjww;
yiqmcmksqjww = scvmjwhwfhna[kgfvcoakbkgf->yfzeivmnnrai.yfzeivmnnrai](jcihqccvysei, zdtizrjftpni);
} } jxctryevobrs++;
} if (!kgfvcoakbkgf->yfzeivmnnrai.cwreubgjosza) { zdtizrjftpni = yiqmcmksqjww;
jcihqccvysei = kgfvcoakbkgf->qpvvigyfqwqu;
yiqmcmksqjww = scvmjwhwfhna[kgfvcoakbkgf->qnnibacbltlo](jcihqccvysei,zdtizrjftpni);
jedhoqnrupdm = yiqmcmksqjww;
if (kgfvcoakbkgf->odhazyjtfxnx >= 0) { if (kgfvcoakbkgf->yfzeivmnnrai.byte) { targetPos = (shzveqsbwpgu->nshlnwwdnxmh[odhazyjtfxnx]+7)/8-1+kgfvcoakbkgf->uegiyqtqayhs;
if (xmtdckoioaxx) { sxsgupbcixzv[odhazyjtfxnx][targetPos] = yiqmcmksqjww;
} else { return yiqmcmksqjww == sxsgupbcixzv[odhazyjtfxnx][targetPos];
} } else { targetPos = (shzveqsbwpgu->nshlnwwdnxmh[odhazyjtfxnx]+7)/8*2-1+kgfvcoakbkgf->uegiyqtqayhs;
if (xmtdckoioaxx) { ocyrmoulkhow(odhazyjtfxnx, targetPos, yiqmcmksqjww&0x0f);
} else { return (yiqmcmksqjww&0x0f) == aqtdednzjrll(odhazyjtfxnx, targetPos);
} } } } return true;
} static bool lluxgncggttr(const struct kdjigrgqrois* shzveqsbwpgu, const struct odxfhxsrevig* kgfvcoakbkgf, bool xmtdckoioaxx) { uint8_t jxctryevobrs, emubljrywvpd, tizdudwljawi, nibStart, nibEnd;
uint8_t htodnioledof;
uint8_t jcihqccvysei, zdtizrjftpni;
uint8_t yiqmcmksqjww;
uint8_t odhazyjtfxnx, targetPos;
emubljrywvpd = kgfvcoakbkgf->ncudadtiieiw>>4;
tizdudwljawi = kgfvcoakbkgf->ncudadtiieiw&0x0f;
odhazyjtfxnx = kgfvcoakbkgf->odhazyjtfxnx&0x03;
jxctryevobrs = emubljrywvpd;
if (kgfvcoakbkgf->yfzeivmnnrai.dizzshmncdny) { yiqmcmksqjww = jedhoqnrupdm;
} else { yiqmcmksqjww = 0;
} while (jxctryevobrs <= tizdudwljawi) { if (jxctryevobrs == emubljrywvpd) { nibStart = kgfvcoakbkgf->kjdtvsdspmqy;
} else { nibStart = 0;
} if (jxctryevobrs == tizdudwljawi) { nibEnd = ((shzveqsbwpgu->nshlnwwdnxmh[jxctryevobrs]+7)/8)*2-1+kgfvcoakbkgf->hvqubynhawbz;
} else { nibEnd = ((shzveqsbwpgu->nshlnwwdnxmh[jxctryevobrs]+7)/8)*2-1;
} for (htodnioledof=nibStart; htodnioledof<=nibEnd; htodnioledof=htodnioledof+kgfvcoakbkgf->nedpotigczcm) {
zdtizrjftpni = cgslostmrgck(jxctryevobrs, htodnioledof);
if (kgfvcoakbkgf->yfzeivmnnrai.cwreubgjosza) { jcihqccvysei = kgfvcoakbkgf->qpvvigyfqwqu;
targetPos = htodnioledof+kgfvcoakbkgf->uegiyqtqayhs;
yiqmcmksqjww = scvmjwhwfhna[kgfvcoakbkgf->yfzeivmnnrai.yfzeivmnnrai](jcihqccvysei, zdtizrjftpni);
yiqmcmksqjww &= kgfvcoakbkgf->qnnibacbltlo;
if (kgfvcoakbkgf->odhazyjtfxnx >= 0) { if (xmtdckoioaxx) { yiqmcmksqjww = (cgslostmrgck(odhazyjtfxnx, targetPos)&(~kgfvcoakbkgf->qnnibacbltlo)) | yiqmcmksqjww;
wsbwmopcmcwu(odhazyjtfxnx, targetPos, yiqmcmksqjww);
} else { if (yiqmcmksqjww != (cgslostmrgck(odhazyjtfxnx, targetPos)&(kgfvcoakbkgf->qnnibacbltlo))) { return false;
} } } } else { jcihqccvysei = yiqmcmksqjww;
yiqmcmksqjww = scvmjwhwfhna[kgfvcoakbkgf->yfzeivmnnrai.yfzeivmnnrai](jcihqccvysei, zdtizrjftpni);
} } jxctryevobrs++;
} if (!kgfvcoakbkgf->yfzeivmnnrai.cwreubgjosza) { zdtizrjftpni = yiqmcmksqjww;
jcihqccvysei = kgfvcoakbkgf->qpvvigyfqwqu;
yiqmcmksqjww = scvmjwhwfhna[kgfvcoakbkgf->qnnibacbltlo](jcihqccvysei,zdtizrjftpni);
jedhoqnrupdm = yiqmcmksqjww;
if (kgfvcoakbkgf->odhazyjtfxnx >= 0) { if (kgfvcoakbkgf->yfzeivmnnrai.byte) { targetPos = (shzveqsbwpgu->nshlnwwdnxmh[odhazyjtfxnx]+7)/8-1+kgfvcoakbkgf->uegiyqtqayhs;
if (xmtdckoioaxx) { sxsgupbcixzv[odhazyjtfxnx][targetPos] = yiqmcmksqjww;
} else { return yiqmcmksqjww == sxsgupbcixzv[odhazyjtfxnx][targetPos];
} } else { targetPos = (shzveqsbwpgu->nshlnwwdnxmh[odhazyjtfxnx]+7)/8*2-1+kgfvcoakbkgf->uegiyqtqayhs;
if (xmtdckoioaxx) { wsbwmopcmcwu(odhazyjtfxnx, targetPos, yiqmcmksqjww&0x0f);
} else { return (yiqmcmksqjww&0x0f) == cgslostmrgck(odhazyjtfxnx, targetPos);
} } } } return true;
} static bool puznxqrbhbkt(const struct kdjigrgqrois* shzveqsbwpgu, const struct odxfhxsrevig* kgfvcoakbkgf, bool xmtdckoioaxx) { uint8_t jxctryevobrs, emubljrywvpd, tizdudwljawi, byteStart, byteEnd;
uint8_t htodnioledof;
uint8_t jcihqccvysei, zdtizrjftpni;
uint8_t yiqmcmksqjww;
uint8_t odhazyjtfxnx, targetPos;
emubljrywvpd = kgfvcoakbkgf->ncudadtiieiw>>4;
tizdudwljawi = kgfvcoakbkgf->ncudadtiieiw&0x0f;
odhazyjtfxnx = kgfvcoakbkgf->odhazyjtfxnx&0x03;
jxctryevobrs = emubljrywvpd;
if (kgfvcoakbkgf->yfzeivmnnrai.dizzshmncdny) { yiqmcmksqjww = jedhoqnrupdm;
} else { yiqmcmksqjww = 0;
} while (jxctryevobrs <= tizdudwljawi) { if (jxctryevobrs == emubljrywvpd) { byteStart = kgfvcoakbkgf->kjdtvsdspmqy;
} else { byteStart = 0;
} if (jxctryevobrs == tizdudwljawi) { byteEnd = (shzveqsbwpgu->nshlnwwdnxmh[jxctryevobrs]+7)/8-1+kgfvcoakbkgf->hvqubynhawbz;
} else { byteEnd = (shzveqsbwpgu->nshlnwwdnxmh[jxctryevobrs]+7)/8-1;
} for (htodnioledof=byteStart; htodnioledof<=byteEnd; htodnioledof=htodnioledof+kgfvcoakbkgf->nedpotigczcm) {
zdtizrjftpni = sxsgupbcixzv[jxctryevobrs][htodnioledof];
if (kgfvcoakbkgf->yfzeivmnnrai.cwreubgjosza) { jcihqccvysei = kgfvcoakbkgf->qpvvigyfqwqu;
targetPos = htodnioledof+kgfvcoakbkgf->uegiyqtqayhs;
yiqmcmksqjww = scvmjwhwfhna[kgfvcoakbkgf->yfzeivmnnrai.yfzeivmnnrai](jcihqccvysei, zdtizrjftpni);
yiqmcmksqjww &= kgfvcoakbkgf->qnnibacbltlo;
if (kgfvcoakbkgf->odhazyjtfxnx >= 0) { if (xmtdckoioaxx) { yiqmcmksqjww = (sxsgupbcixzv[odhazyjtfxnx][targetPos]&(~kgfvcoakbkgf->qnnibacbltlo)) | yiqmcmksqjww;
sxsgupbcixzv[odhazyjtfxnx][targetPos] = yiqmcmksqjww;
} else { if (yiqmcmksqjww != (sxsgupbcixzv[odhazyjtfxnx][targetPos]&(kgfvcoakbkgf->qnnibacbltlo))) { return false;
} } } } else { jcihqccvysei = yiqmcmksqjww;
yiqmcmksqjww = scvmjwhwfhna[kgfvcoakbkgf->yfzeivmnnrai.yfzeivmnnrai](jcihqccvysei, zdtizrjftpni);
} } jxctryevobrs++;
} if (!kgfvcoakbkgf->yfzeivmnnrai.cwreubgjosza) { zdtizrjftpni = yiqmcmksqjww;
jcihqccvysei = kgfvcoakbkgf->qpvvigyfqwqu;
yiqmcmksqjww = scvmjwhwfhna[kgfvcoakbkgf->qnnibacbltlo](jcihqccvysei,zdtizrjftpni);
jedhoqnrupdm = yiqmcmksqjww;
if (kgfvcoakbkgf->odhazyjtfxnx >= 0) { targetPos = (shzveqsbwpgu->nshlnwwdnxmh[odhazyjtfxnx]+7)/8-1+kgfvcoakbkgf->uegiyqtqayhs;
if (xmtdckoioaxx) { sxsgupbcixzv[odhazyjtfxnx][targetPos] = yiqmcmksqjww;
} else { return yiqmcmksqjww == sxsgupbcixzv[odhazyjtfxnx][targetPos];
} } } return true;
} static bool sclhjmnqibbk(const struct kdjigrgqrois* shzveqsbwpgu, const struct odxfhxsrevig* kgfvcoakbkgf, bool xmtdckoioaxx) { (void)shzveqsbwpgu;
if (xmtdckoioaxx) { vwvzidbltkov(kgfvcoakbkgf);
} return true;
} static bool zigckxbdzdvg(const struct kdjigrgqrois* shzveqsbwpgu, const struct odxfhxsrevig* kgfvcoakbkgf, bool xmtdckoioaxx) { bool yiqmcmksqjww;
struct kdjigrgqrois inkoncmbsghk;
inkoncmbsghk.spec = shzveqsbwpgu->spec;
inkoncmbsghk.signature = shzveqsbwpgu->signature;
inkoncmbsghk.bitLen = shzveqsbwpgu->bitLen;
inkoncmbsghk.nshlnwwdnxmh[0] = shzveqsbwpgu->uuipfhjicnzd->nshlnwwdnxmh.hngolhghqowm;
inkoncmbsghk.nshlnwwdnxmh[1] = shzveqsbwpgu->uuipfhjicnzd->nshlnwwdnxmh.jwpajwdilkuh;
inkoncmbsghk.nshlnwwdnxmh[2] = shzveqsbwpgu->uuipfhjicnzd->nshlnwwdnxmh.msoqccwsovjs;
inkoncmbsghk.nshlnwwdnxmh[3] = shzveqsbwpgu->uuipfhjicnzd->nshlnwwdnxmh.dbcrfmkicojr;
fefldogauyki(shzveqsbwpgu);
cycwqtmggord(shzveqsbwpgu);
hdewbzptlbih(&inkoncmbsghk, (bc7215DataVarPkt_t*)&qlavfhidhmdq);
yiqmcmksqjww = puznxqrbhbkt(&inkoncmbsghk, kgfvcoakbkgf, xmtdckoioaxx);
fefldogauyki(&inkoncmbsghk);
cycwqtmggord(&inkoncmbsghk);
hdewbzptlbih(shzveqsbwpgu, (bc7215DataVarPkt_t*)&qlavfhidhmdq);
return yiqmcmksqjww;
}
#ifndef _NO_DEPRECATED
static bool sjbvlmyqyfqc(const struct kdjigrgqrois* shzveqsbwpgu, const struct odxfhxsrevig* kgfvcoakbkgf, bool xmtdckoioaxx) { int8_t htodnioledof;
(void)xmtdckoioaxx;
for (htodnioledof=0; htodnioledof<kgfvcoakbkgf->hvqubynhawbz; htodnioledof++)
{ if (sxsgupbcixzv[kgfvcoakbkgf->ncudadtiieiw][kgfvcoakbkgf->kjdtvsdspmqy+htodnioledof] != *(shzveqsbwpgu->kheyzdjrjuew.ovxhljuweifs+htodnioledof)) { return false;
} } return true;
}
#endif
static void nvptsvwjxykb(const bc7215DataVarPkt_t* dhurvqddfmzf, const bc7215FormatPkt_t* fqfxxvnmkfsk) { (void)dhurvqddfmzf;
(void)fqfxxvnmkfsk;
mkrbbjgfiafa = vyudfzxzxuqv;
mkrbbjgfiafa.bitLen = ((const struct aaqxyrxbybvu*)eshuyivywcyl->fgstngnlzpzg.ovxhljuweifs)->shzveqsbwpgu.bitLen;
rcmwutmxcidu = qobvowrftgaq;
bmmyftuypsva = jadyfbnomgtt;
mkrbbjgfiafa.data[19] = 0x01;
mkrbbjgfiafa.data[7] = (mkrbbjgfiafa.data[7]&0xf0)|0x05;
} static const char*	VERSION = "V8.1.3";
static const uint8_t yesurpvnxprn[] =  {0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x2f};
static const uint8_t iavmeixdhscu[] =  {0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x00};
static const uint8_t nsynuixoqddb[] =  {0x16, 0x17, 0x18, 0x19, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x30};
static const uint8_t wcffplmknqjq[] =  {0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d};
static const uint8_t xgajasxpvaaj[] =  {0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a};
static const uint8_t tlvwpuqzrocu[] =  {0x0f, 0x0e, 0x0d, 0x0c, 0x0b, 0x0a, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01};
static const uint8_t itetzelofusv[] =  {0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A, 0x09};
static const uint8_t jkadkrgpzgra[] =  {0x0f, 0x1e, 0x2d, 0x3c, 0x4b, 0x5a, 0x69, 0x78, 0x87, 0x96, 0xa5, 0xb4, 0xc3, 0xd2, 0xe1};
static const uint8_t eljzwfefkbgl[] =  {0x00, 0x00, 0x08, 0x0c, 0x04, 0x06, 0x0e, 0x0a, 0x02, 0x03, 0x0b, 0x09, 0x01, 0x05, 0x0d, 0x07};
static const uint8_t zkxewdgxxczo[] = {0x10, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02};
static const uint8_t abiypmrtzxpm[] = {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x00};
static const uint8_t toplvrhwbvmk[] = {0x61, 0x71, 0x81, 0x91, 0x02, 0x12, 0x22, 0x32, 0x42, 0x52, 0x62, 0x72, 0x82, 0x92, 0x03};
static const uint8_t oibwwdmldgns[] = {0x00, 0x00, 0x01, 0x03, 0x02, 0x06, 0x07, 0x05, 0x04, 0x0c, 0x0d, 0x09, 0x08, 0x0a, 0x0b, 0x0e};
static const uint8_t cgvksurxswjr[] = {0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e};
static const uint8_t wgrzvmgvxdbc[] = {0x19, 0x18, 0x17, 0x16, 0x15, 0x14, 0x13, 0x12, 0x11, 0x10, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B};
static const uint8_t iomplekazizk[] = {0x0d, 0x0e, 0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b};
static const uint8_t qsjskffkkdso[] = {0x00, 0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c};
static const uint8_t isxphlemnplx[] = {0x00, 0x0a, 0x14, 0x1e, 0x28, 0x32, 0x3c, 0x46, 0x50, 0x5a, 0x64, 0x6e, 0x78, 0x82, 0x8c};
static const uint8_t ecnfemzkobsa[] = {0x18, 0x1A, 0x1c, 0x1e, 0x20, 0x22, 0x24, 0x26, 0x28, 0x2a, 0x2c, 0x2e, 0x30, 0x32, 0x34};
static const uint8_t zyjffvcebxgi[] = {0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x00};
static const uint8_t flqyofepsvvg[] = {0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27};
static const uint8_t xyulyfqvekqy[] = {0x0e, 0x0d, 0x0c, 0x0b, 0x0a, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00};
static const uint8_t smjxfwmclffb[] = {0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A};
static const uint8_t fsfcmbkqsvit[] = {0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x00};
static const uint8_t gcajfekxbndx[] = {0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x60};
static const uint8_t bjwkqubxshep[] = {0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x40};
static const uint8_t fqqkbgmarcmz[] = {0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24};
static const uint8_t cnvrmmtnbwib[] = {0x0f, 0x1e, 0x2d, 0x3c, 0x4b, 0x5a, 0x69, 0x78, 0x87, 0x96, 0xa5, 0xb4, 0xc3, 0xd2, 0xe1};
static const uint8_t pvewsnmnbdki[] = {0x00, 0x01, 0x03, 0x02, 0x06, 0x07, 0x05, 0x04, 0x0c, 0x0d, 0x0f, 0x0e, 0x0a, 0x0b, 0x09};
static const uint8_t uulrtvniqbbi[] = {0x42, 0x44, 0x45, 0x47, 0x49, 0x4b, 0x4d, 0x4e, 0x50, 0x52, 0x54, 0x56, 0x57, 0x59, 0x5b};
static const uint8_t wcxlbzbhtwjv[] = {0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07, 0x0f};
static const uint8_t zzwjugygfzah[] = {0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x03, 0x00};
static const uint8_t ughiiqecuihs[] = {0x69, 0x79, 0x89, 0x99, 0x0A, 0x1A, 0x2A, 0x3A, 0x4A, 0x5A, 0x6A, 0x7A, 0x8A, 0x9A, 0x0B};
static const uint8_t uligrmwovbln[] = {0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19};
static const uint8_t nqbpxohgetod[] = {0x30, 0x32, 0x34, 0x36, 0x38, 0x3A, 0x3C, 0x3E, 0x40, 0x42, 0x44, 0x46, 0x48, 0x4A, 0x4C, 0xC0};
static const uint8_t blapmzvtxfpb[] = {0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2a, 0x2b};
static const uint8_t dayiqypyjymc[] = {0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05};
static const uint8_t avvbimutskbi[] = {0x00, 0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07};
static const uint8_t mftyhtmppicz[] = {0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10};
static const uint8_t nfhmibmlxsnc[] = {0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2a, 0x2b, 0x2c, 0x00};
static const uint8_t jfribqhxkcfd[] = {0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x00, 0x01, 0x02, 0x03};
static const uint8_t sqjlpwsojbia[] = {0x07, 0x07, 0x06, 0x05, 0x04, 0x03, 0x07, 0x06, 0x05, 0x04, 0x03, 0x07, 0x06, 0x05, 0x04};
static const uint8_t zkyldkuyylyj[] = {0x09, 0x09, 0x09, 0x09, 0x09, 0x09, 0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0x07, 0x07, 0x07};
static const uint8_t mqywnqvipdef[] = {0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06};
static const uint8_t lgyvrryfcusz[] = {0x30, 0x31, 0x32, 0x33, 0x34, 0x38, 0x39, 0x3a, 0x3b, 0x3c, 0x40, 0x41, 0x42, 0x43, 0x44};
static const uint8_t klwpsnaremnn[]  = {0,   1,   4,  2,  3};
static const uint8_t ybqftvqsjyve[]  = {0,   1,   0,  2,  3};
static const uint8_t osnwjoweeogm[]  = {0,   1,   4,  2,  6};
static const uint8_t aroekziciyls[]  = {0,   1,   8,  2,  4};
static const uint8_t dfwugjfgfggl[]  = {0,   1,   3,  2,  4};
static const uint8_t fcuomdkkfykn[]  = {4,   2,   1,  3,  5};
static const uint8_t zsbjpadkqkhk[]  = {8,   3,   1,  2,  7};
static const uint8_t eyqyhfzdrvxx[]  = {1,   0,   3,  2,  2};
static const uint8_t fawtprpzhhee[]  = {0,   3,   4,  2,  6};
static const uint8_t zkbwbzcqcsfl[] = {7,   0,   3,  1,  2};
static const uint8_t ybpyvlaaytbg[] = {4,   0,   3,  1,  2};
static const uint8_t xxosrxtozcbu[] = {7,   5,   3,  6,  4};
static const uint8_t nagzypxufjsh[] = {7,   6,   3,  5,  4};
static const uint8_t rkfhniaccipe[] = {7,   6,   3, 0x0a,0x0b};
static const uint8_t skxcssaagoud[] = {4,   0,   1,  2,  3};
static const uint8_t nclkbzyijjmp[] = {0x13, 0x02, 0x01, 0x03, 0x13};
static const uint8_t kxdkesgfinud[] = {8,   4,   8,  2,  1};
static const uint8_t esmhlrvmdxsn[] = {0,   2,   6,  4,  8};
static const uint8_t zqnckmekinml[] = {1,   2,   4,  0,  8};
static const uint8_t jtaryvaqudln[] = {0,   0,   2,  1,  5};
static const uint8_t gbcpixqwpgdw[] = {6,   2,   4,  3,  0};
static const uint8_t cytfrmrvpryw[] = {0,   2,   1,  3,  4};
static const uint8_t kvhxtlfrqrhg[] = {2,   0,   3,  1,  1};
static const uint8_t aqleomuwmxuh[] = {8,   8, 0x0a, 0x0b,  9};
static const uint8_t rhgrgpfgjtpx[] = {5,   1,   2,  4,  3};
static const uint8_t lilljgxuegds[] = {4,   0,   1,  2,  5};
static const uint8_t kbmodlblaucy[] = {3,   1,   3,  2,  2};
static const uint8_t pksciaxzldqs[] = {0,   1,   2,  4,  3};
static const uint8_t szfgznqnnsmy[] = {0,   1,   2,  3,  4};
static const uint8_t bwhuawgvrvdd[] = {1,   2,   1,  3,  5};
static const uint8_t qqlbxsshbipj[] = {0x42,  0x42, 0xc3,  0x42,  0xc3};
static const uint8_t lrpdggnbestj[] = {0,   2,   4,  1,  3};
static const uint8_t vtxztbnmjowx[] = {0,   8,   4, 0x0c,  0x0c};
static const uint8_t fmxgjfnrbqki[] = {2,   0,   4,   1,  3};
static const uint8_t xgrgvuukfmxw[] = {8,   4,   2,  1,  0};
static const uint8_t gisktbnifqko[] = {1,   2,   0,  3,  4};
static const uint8_t hrtkqdhjbsji[] = {0x23, 5, 0x21,  7,  9};
static const uint8_t jamvdqsxoxbt[] = {0x0B,  0x06, 0x08,  0x04,  0x02};
static const uint8_t pnkrgohcdztf[] = {2,   2,   1,  3,  0};
static const uint8_t indxgieqtgxq[] = {2,   1,   1,  3,  0};
static const uint8_t kcjvjfzxugrm[] = {9,   9,   1,  5,  0x0d};
static const uint8_t nzktiygcyrql[] = {9,   6,   1,  5,  0x0d};
static const uint8_t tjonhriptfeb[] = {6,   2,   1,  3,  0};
static const uint8_t jhpavfqdtmow[] = {0,   3,   1,  2,  7};
static const uint8_t lmnidopusvcf[] = {3,   1,   2,  5,  0};
static const uint8_t isjaoyqxvcxy[] = {2,   3,   1,  2,  2};
static const uint8_t rydzwodolknx[] = {7,   7,   1,  5,  3};
static const uint8_t ttywxwiboswj[] = {3,   2,   1,  7,  0};
static const uint8_t zuyjppaxffro[] = {0,   4,   2,  6,  0};
static const uint8_t tvqvmuaqqrvx[] = {0,   4,   7,  2,  1};
static const uint8_t kdghctskeoas[] = {0,   8,   1,  4,  2};
static const uint8_t gngliwbhzkwa[] = {7,   6,   8,  4,  2};
static const uint8_t gnxpzwysuqfg[] = {0,   2,   1,  4,  8};
static const uint8_t wuhxjlaconjm[] = {0,   4,   3,  1,  2};
static const uint8_t zszvtuujqvjr[] = {2,   4,   3,  5,  0x0c};
static const uint8_t ktjpnggotfrz[] = {7,   3,   6,  9,  8};
static const uint8_t rhhlairhixpb[] = {3,   0,   4,  1,  2};
static const uint8_t gemltkeahgdn[] = {7,   6,   4,  5,  3};
static const uint8_t lwmbjanqpqpc[] = {5,   2,   1,  3,  4};
static const uint8_t lujrsilsbltr[] = {1,   3,   4,  2,  6};
static const uint8_t nmihyxtsufug[] = {3,   2,   1,  7,  0};
static const uint8_t qvzisowsrvzp[] = {0x0a, 2,  8,  1,  4};
static const uint8_t xjvbuhlajqgw[] = {7,  4,  6,  4,  3};
static const uint8_t xrqmfcrohsmx[] = {1,  6,  6,  5,  0x0a};
static const uint8_t jwbcjityfwac[] = {0,  0,  0,  4,  3};
static const uint8_t sdvufbysfqjr[] = {1,  1,  3,  2,  0};
static const uint8_t mwxhncyyiyqh[] = {1,  6,  0x0d,  4,  9};
static const uint8_t jvnztqhtnffx[] = {1,  2,  6,  3,  0};
static const uint8_t xxnbypnhwalr[] = {4,  2,  6,  3,  5};
static const uint8_t wpzrfibswrrh[] = {1,  1,  1,  1,  1};
static const uint8_t wlyyfelnkzfi[] = {0x23, 0x03, 0x03, 0x22, 0x21};
static const uint8_t nskpidmbcnjt[] = {7,  3,  1,  2,  2};
static const uint8_t epdennojosof[] = {0x05, 0x41, 0x24, 0x42, 0x03};
static const uint8_t ywrteveinyvh[] = {0,  0,  1,  0,  2};
static const uint8_t obscdisokwwa[] = {0,  0,  2,  4,  6};
static const uint8_t tmoapbkilvhx[] = {4,  2,  0,  1,  3};
static const uint8_t uvujmtkcqoiv[] = {5,  1,  3,  2,  4};
static const uint8_t ezndejkzdwby[] = {0,  0,  2,  6,  4};
static const uint8_t qbfgmvevkgcr[] = {1,  2,  4,  3,  5};
static const uint8_t iynzkgbhspof[] = {1,  4,  2,  3,  5};
static const uint8_t npecguqhfkkt[] = {1,  2,  6,  4,  3};
static const uint8_t tzgxzqkfiben[] = {4,  6,  0,  2,  3};
static const uint8_t ajabnpypxszy[] = {3,  2,  0,  1,  2};
static const uint8_t jaobzjsamwcf[] = {0,  8,  2,  4,  1};
static const uint8_t kowbieqwlbpm[] = {3,  1,  2,  0,  2};
static const uint8_t wnwydwbjshnc[] = {0,  1,  2,  4,  8};
static const uint8_t syvkgjpcbbei[] = {0,  2,  8,  4,  3};
static const uint8_t zkdvdrtxxrhx[] = {0,  4,  0x0c,  8,  4};
static const uint8_t nkvykjwizqni[] = {3,  1,  2,  4,  5};
static const uint8_t xkzkwxgbkbwf[] = {0,  2,  1,  2,  3};
static const uint8_t qyadwftjvequ[] = {3,  1,  0,  2,  4};
static const uint8_t yrxjsauslprr[] = {2,  0,  3,  1,  4};
static const uint8_t hljquovxzgfh[] = {7,  3,  6,  5,  1};
static const uint8_t byncdlnkbwuv[] = {0,  3,  1,  3,  4};
static const uint8_t cybnccymaorr[] = {0,  2,  3,  2,  4};
static const uint8_t zweqzhpfquul[] = {0x0c,  2,  1,  3,  4};
static const uint8_t lgjaumkzwgpi[] = {8,  0,  1,  2,  4};
static const uint8_t rycifytdnudx[] = {2,  3,  0,  2,  1};
static const uint8_t uqvgywnmerzv[] = {5,  1,  4,  0,  3};
static const uint8_t cebtibulumkf[]= {1,  2,  4,  0,  6};
static const uint8_t qifhtoqqzsmy[]= {0,  1,  4,  3,  2};
static const uint8_t fpgevjrrppie[]= {0,  8,  1,  2,  4};
static const uint8_t seowdspzlhoq[]= {0,  1,  4,  5,  3};
static const uint8_t kdgkzyejcxva[]= {0,  4,  9,  4,  9};
static const uint8_t pfnnwdjtlbux[]= {8,  4,  0,  2,  1};
static const uint8_t ugfettxtzvmu[] = { 0,    1,     3,    5, 5};
static const uint8_t pxrplmlbjsmu[] = { 0,    1,     2,    3, 3};
static const uint8_t qawevoxbehgi[] = { 5,    3,     2,    1, 1};
static const uint8_t xxnpenfefvwy[] = { 0,    2,     3,    1, 1};
static const uint8_t mbjbojreykno[] = { 0,    2,     3,    5, 5};
static const uint8_t zrnrfxpyxqdn[] = { 0,    2,     0,    4, 4};
static const uint8_t fbqfpruwxawg[] = { 5,    1,     2,    4,  0};
static const uint8_t mscfzyeboixu[] = {0x0a,  3,     5,    7, 7};
static const uint8_t khcvmumszyne[] = { 0,    1,     2,    4};
static const uint8_t jyqazkeoaped[] ={ 7,    3,     2,    1, 1};
static const uint8_t uxfnphantyno[] ={ 0,    3,     2,    1, 1};
static const uint8_t eyojthsxxrti[] ={ 7,    5,     3,    1, 1};
static const uint8_t wnivcgizifji[] ={ 7,    4,     5,    6, 6};
static const uint8_t rigdugjowjha[] ={ 3,    0,     1,    2, 5};
static const uint8_t ixdyyzkferrh[] ={0xFF, 0x20, 0x40, 0x60, 0x60};
static const uint8_t tzcwcehgndva[] ={ 7,    6,     5,    4, 4};
static const uint8_t pnsjkkzedchd[] ={ 3,    4,     3,    2, 2};
static const uint8_t msjhtfzlamsp[] ={ 8,    4,     2,    1, 0};
static const uint8_t chzhtjcvwqms[] ={ 1,    4,     8,    2, 2};
static const uint8_t hytgptmhvrcd[] = { 6,    1,    3,    5,  5};
static const uint8_t dgndpjpipgeb[] = { 5,    4,     2,    1, 0};
static const uint8_t ioimiaznntiw[] = { 4,    3,     2,    1, 1};
static const uint8_t zwxjxwbjkkqb[] = { 5,    7,     2,   1,  0};
static const uint8_t hgmmvxysuqkh[] = { 5,    1,     2,    3, 3};
static const uint8_t icgmlvzoyhwj[] = { 4,    6,     5,    7, 4};
static const uint8_t ruqjijcpnpfa[] = { 0,    3,     1,    2, 0};
static const uint8_t rooptcylbuyn[] = { 0x0a, 4,     6,    7};
static const uint8_t qdhcshkfupkm[] = { 0,    8,   0x0c,   4,  2};
static const uint8_t btjmcnhdbjhv[] = { 5,    0,     2,    4, 0};
static const uint8_t duufbnoqquua[] = {0xff, 0x8a, 0xad, 0xd0, 0xd0};
static const uint8_t acudvgmiohqz[] = {8, 1, 2, 4, 4};
static const uint8_t clmudmnzybys[] = {0x00, 0x0a, 0x32, 0x63, 0x63};
static const uint8_t uhtggzmnvqwz[] = {3, 2, 1, 0, 0};
static const uint8_t smiqakoclcjh[] = {0x27, 0x17, 0x07, 0x36};
static const uint8_t ywtxvccdnvhm[] = {7, 5, 4, 3, 3};
static const uint8_t pbvggpmjsmwa[] = {4, 0, 2, 3};
static const uint8_t rxvuabhfspsf[] = {7, 1, 2, 3, 3};
static const uint8_t mefowlgychxe[] = {6, 0, 2, 4, 4};
static const uint8_t yfohupfsvwbj[] = {7, 5, 3, 2, 2};
static const uint8_t gxnkayorkkno[] = {0x0f, 2, 4, 6, 6};
static const uint8_t blflvskhozvo[] = {0, 4, 6, 2, 2};
static const uint8_t gljwqnkgvonk[] = {0, 2, 4, 5, 6};
static const uint8_t mksktcjliwhi[] = {0, 1, 6, 8, 8};
static const uint8_t bmbbqcewasii[] = {1, 2, 4, 8, 8};
static const uint8_t faajsjsemavy[] = {5, 2, 3, 4, 4};
static const uint8_t uhkpvdynyvsa[] = {1, 2, 4, 5, 3};
static const uint8_t qkovyyumaseg[] = {5, 1, 3, 4, 4};
static const uint8_t mzpabkrzmugx[] = {1, 8, 4, 2, 2};
static const uint8_t kygodkepoucb[] = {7, 2, 1, 0, 2};
static const uint8_t yfsxyagqyajn[] = {4, 4, 5, 6, 6};
static const uint8_t cjggoagxlxcb[] = {4, 7, 6, 5};
static const uint8_t rlxcceajnzyl[] = {0, 8, 0x0c, 0x0c};
static const uint8_t irobojujhfyg[] = {0, 3, 7, 5};
static const uint8_t ullpmggbapds[] = {0, 2, 6, 5};
static const uint8_t zycziltiqeqh[] = {0, 3, 4, 5};
static const uint8_t hfjfaictqjnj[] = {2, 3, 5, 7};
static const uint8_t izjqcngmafuk[] = {0, 2, 1, 3};
static const uint8_t fqqkwwpykiir[] = {1, 2, 3, 4};
static const uint8_t ebksofhlgkpa[] = {7, 1, 3, 5};
static const uint8_t veqpimicnwaj[] = {4, 5, 6, 7};
static const uint8_t gxxnsdixsthv[] = {0, 2, 6, 1};
static const uint8_t zdaxnykiemnp[] = {7, 4, 2, 1};
static const uint8_t ijcuojfqqiuu[] = {4, 0, 1, 0};
static const uint8_t ilwsoyzatyov[] = {0, 2, 1, 8};
static const uint8_t wxeenrqzpzbd[] = {7, 6, 4, 3};
static const uint8_t jkswdfgufkca[] = {8, 2, 6, 4};
static const uint8_t nwkdkamttlvn[] = {6, 2, 3, 4, 1};
static const uint8_t dilswyxodmcr[] = {4, 1, 2, 3};
static const uint8_t rkpucvzgaotl[] = {4, 0, 1, 2};
static const uint8_t yhxfbsyfdnrs[] = {3, 3, 1, 0};
static const uint8_t hrrwiswieqyp[]   = {0, 1, 6, 4,  5, 5};
static const uint8_t mwqnxiyrlxlh[]   = {3, 4, 1, 5,  0, 0};
static const uint8_t xwpraoqjyriq[] = {0, 1, 3, 3, 0};
static const uint8_t nnalrticcmtl[]   = {3, 3, 0x0c, 3, 0x0b, 3};
static const uint8_t xofnhcyesrof[] = {1, 2, 3, 5 };
static const uint8_t hvkesnuxkauc[]   = {8, 8, 8, 8, 5, 5};
static const uint8_t ibdfuvhhbxip[] = {0x66, 0x28, 0x3c, 0x64, 0x65};
static const uint8_t fhhpwxvyklnn[] = {0x66, 0x14, 0x3c, 0x64, 0x65};
static const uint8_t xzabpopfxpzr[]   = {1, 1, 1, 2, 0x0f, 0x0f};
static const uint8_t lngoeqphvnen[] = {1, 0, 0, 0, 0};
static const uint8_t puyaxzxepvdq[]   = {1, 2, 4, 6, 3, 3};
static const uint8_t hjnvmznearzt[]   = {5, 7, 0x0b, 9, 0x0c, 0x0c};
static const uint8_t cvnwzckfulgx[]   = {6, 7, 2, 3, 0, 1};
static const uint8_t puvfsaegothg[]   = {5, 4, 6, 2, 7, 7};
static const uint8_t aghhidcycdjo[]  = {2, 2, 6, 0x11, 1, 1};
static const uint8_t yrnzpkzxrloi[]  = {1, 2, 6, 0x11, 0x25, 0x25};
static const uint8_t yrlvcfroqdpn[]  = {9, 8, 4, 5, 1, 1};
static const uint8_t cxeasujrjham[]  = {1, 1, 0x0f, 2, 0x0f, 0x0f};
static const uint8_t mtiuktpixtdc[] = {0x5d, 0x5d, 0x41, 0x5d, 0x5d};
static const uint8_t qrxmfvknnijn[] = {1, 1, 0, 1, 1};
static const uint8_t krzvsrfegkai[] = {0xb9, 0xb9, 0x82, 0xb9, 0xb9};
static const uint8_t jaripcivdrkj[]  = {0x14, 0x10, 0x08, 0x0c, 0x0c};
static const uint8_t sentaqwqpmtd[] = {0x38, 0x38, 0x00, 0x38, 0x38};
static const uint8_t dmhuhkdxtdkc[]  = {3, 4, 7, 6, 0, 0};
static const uint8_t ivwochzhifej[] = {6, 6, 0, 2, 0};
static const uint8_t ntivtupwshew[] = {0, 0, 1, 1, 0};
static const uint8_t tsrnfzhmsuef[]  = {0, 0, 1, 0, 0, 0};
static const uint8_t wasxtxuhoupi[]  = {0x44, 0x43, 0x13, 0x42, 0x13, 0x13};
static const uint8_t qivvfvgqtivc[]  = {8, 9, 7, 0x0c, 3, 3};
static const uint8_t eocelfpjdawu[] = {0, 0, 0, 0, 0};
static const uint8_t ulckrizgitgy[]  = {2, 3, 1, 5, 0, 0, 0x16};
static const uint8_t xmcrzrykkuhz[]  = {9, 0x0a, 8, 0x0f, 0, 0};
static const uint8_t gsgscnoyofai[] = {1, 3, 0, 0, 1};
static const uint8_t cjoiotohpowo[] = {0x80, 0x14, 0x5a, 0x80};
static const uint8_t gkkstosamumn[]  = {2, 2, 6, 0x11, 0x25, 0x25};
static const uint8_t auuedmtxwygb[]  = {4, 4, 0, 5, 0, 0};
static const uint8_t fmhivgbvipdk[] = {0x79, 0x79, 0x55, 0x79, 0x79};
static const uint8_t nicpsennhqme[] = {0x79, 0x79, 0x42, 0x79, 0x79};
static const uint8_t nemdennzmnye[]  = {0x0d, 0x0d, 0x09, 0x11, 0x06, 0X06};
static const uint8_t coadwkqmwcoz[]  = {8, 8, 8, 8, 5, 6};
static const uint8_t xaypbuvcjaja[]  = {1, 1, 1, 1, 0x0a, 0x0a};
static const uint8_t xqeqkijkquem[] = {0xa7, 0xa7, 0x45, 0x95, 0xa7};
static const uint8_t tfowxtaoekye[]  = {4, 4, 4, 4, 5, 5};
static const uint8_t aoagqbdascbj[]  = {0, 0, 0, 0, 1, 1};
static const uint8_t lbxvxokwhdur[]  = {3, 3, 3, 3, 2, 1};
static const uint8_t sgsofgdeuphx[]  = {2, 2, 2, 2, 2, 1};
static const uint8_t vxbhzwnjxvln[]  = {0, 0, 0, 0, 2, 1};
static const uint8_t fcnzlwhyougv[] = {0, 0, 0, 1, 1};
static const uint8_t gwtcevjpkynw[] = {2, 0, 0, 0, 1};
static const uint8_t spfikypxoocg[] = {7, 0, 1, 2};
static const uint8_t nxgxuxcdjbao[] = {1, 2, 2, 0, 2};
static const uint8_t trrckuxciqru[] = {7, 7, 7, 2, 6};
static const uint8_t iabcprrjchhd[]  = {0, 0, 3, 4, 0, 0};
static const uint8_t erzagzfqxsce[] = {0xf0, 0xf0, 0xc3, 0xb4, 0xf0, 0xf0};
static const uint8_t yuikpzqrywzu[]  = {8, 8, 0, 0, 1, 1};
static const uint8_t pttllbzvuwsn[]  = {2, 2, 2, 2, 1, 2};
static const uint8_t gmlsdfbubkuc[] = {0, 1, 0, 2 };
static const uint8_t zsmzhactucif[] = { 0x00, 0xc0, 0x80, 0x40, 0x00};
static const uint8_t yatsadiaygmw[] = { 0x02, 0x02, 0x00, 0x02, 0x02};
static const uint8_t hgfgowbwimyt[] = { 0x07, 0x07, 0x07, 0x05, 0x07};
static const uint8_t fjmwvhixjqfl[] = { 0x80, 0x00, 0x00, 0x00, 0x00};
static const lygcleobgeet vjkzzagamtio[] = { {2, 1, 2, 0xe0, zsmzhactucif}, {0, 0, 0, 0, NULL} };
static const lygcleobgeet ewatoudyzbqb[] = { {2, 1, 2, 0xe0, zsmzhactucif}, {1, 1, 1, 0x03, yatsadiaygmw}, {1, 0, 11, 0x07, hgfgowbwimyt}, {1, 0, 12, 0x80, fjmwvhixjqfl}, {0, 0, 0, 0, NULL} };
static const uint8_t weafjvwukpwo[] = { 0, 0, 0, 0, 0x04, 0x04};
static const lygcleobgeet lilusymnjwcx[] = { {3, 1, 0, 0x04, weafjvwukpwo}, {0, 0, 0, 0, NULL} };
static const uint8_t ypgvcukyhlex[] = { 0x00, 0x0, 0x10, 0x00, 0x00};
static const lygcleobgeet bscleyzrxbqy[] = { {1, 0, 9, 0x10, ypgvcukyhlex}, {0, 0, 0, 0, NULL} };
static const uint8_t sczmivlwwlvf[] = { 0x20, 0x0, 0x0, 0x00, 0x00};
static const lygcleobgeet vqyzlkabxlpf[] = { {3, 0, 10, 0x20, sczmivlwwlvf}, {0, 0, 0, 0, NULL} };
static const uint8_t maxiykfolvbz[] = { 0x50, 0x50, 0x50, 0x00, 0x40};
static const lygcleobgeet przomtqlpxra[] = { {1, 1, 5, 0x70, maxiykfolvbz}, {0, 0, 0, 0, NULL} };
static const uint8_t ljzanrfersnq[] = {0x02, 0x04, 0x06, 0x08, 0x0a, 0x0c, 0x0e, 0x10, 0x11, 0x13, 0x14, 0x16, 0x18, 0x1a, 0x1b};
static const lygcleobgeet prtwhhiucbev[] = { {0, 0, 3, 0xfF, ljzanrfersnq}, {0, 0, 0, 0, NULL} };
static const uint8_t tgeirginpvdy[] = { 0x09, 0x09, 0x02, 0x09, 0x09};
static const uint8_t oofsebwcqoku[] = { 0, 0, 0, 0, 4, 4};
static const lygcleobgeet vbyrtqvuowpi[] = { {1, 1, 10, 0x0F, tgeirginpvdy}, {3, 1, 0, 0x04, oofsebwcqoku}, {0, 0, 0, 0, NULL} };
static const uint8_t oppmarbkryhy[] = {0xc0, 0xc0, 0xc0, 0x00, 0xc0};
static const lygcleobgeet mwplgijsocxp[] = { {1, 0, 4, 0xC0, oppmarbkryhy}, {3, 0, 10, 0x07, auuedmtxwygb}, {0, 0, 0, 0, NULL} };
static const uint8_t fdsgedqdatio[] = {6, 6, 6, 6, 6};
static const uint8_t lxiokptoyjro[] = {0, 2, 1, 0};
static const lygcleobgeet yrbkxjvxhmod[] = { {1, 0, 4, 0x0f, fdsgedqdatio}, {2, 0, 4, 0x03, lxiokptoyjro}, {0, 0, 0, 0, NULL} };
static const uint8_t iafaiglivtcw[] = {0, 0xc0, 0x80, 0x40};
static const lygcleobgeet ndwodzulpeoi[] = { {2, 1, 2, 0xE0, iafaiglivtcw}, {0, 0, 0, 0, NULL} };
static const uint8_t sqpphejcetwh[] = {0, 0x20, 0x60, 0xA0};
static const lygcleobgeet wtwvqloriidw[] = { {2, 0, 4, 0xE0, sqpphejcetwh}, {0, 0, 0, 0, NULL} };
static const uint8_t ysiluidlqnvg[] = {0, 0, 0, 0, 4};
static const lygcleobgeet zxenslkplgnc[] = { {2, 0, 4, 0x04, ysiluidlqnvg}, {0, 0, 0, 0, NULL} };
static const uint8_t cgpttwlbwtaq[] = {0, 0, 0, 0, 0};
static const lygcleobgeet jctlhxnxakbi[] = { {2, 0, 4, 0xff, cgpttwlbwtaq}, {0, 0, 0, 0, NULL} };
static const uint8_t dlmlajwgtniy[] = {0x10, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};
static const lygcleobgeet djzhugjeizbo[] = { {0, 2, 3, 0x10, dlmlajwgtniy}, {0, 0, 0, 0, NULL} };
static const uint8_t nphtnclrpxie[] = {0, 0, 0x08, 0, 0};
static const lygcleobgeet wsmfxcrfmdhb[] = { {1, 0, 3, 0x08, nphtnclrpxie}, {0, 0, 0, 0, NULL} };
static const int8_t bsucdezhduxa[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t cwdqxraiphdw[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t hpfblzemcdow[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16,  20-16, 21-16, 21-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t lvormwsqmqjw[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16};
static const int8_t ysaaperdhlmr[] = { 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t jhrfmjzzwnqw[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16};
static const int8_t wyzierxyvrke[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t kcgzjnswcxyo[] = { 16-16, 16-16, 16-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16,  20-16, 21-16, 21-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t gzajhisgktow[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16};
static const int8_t pcxfqfrcrtht[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t grmfayntgkol[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16, 30-16};
static const int8_t dulqjsjbglpm[] = { 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c};
static const int8_t ytvijahfvzzx[] = { 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t qzdreliieqwj[] = { 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t ocpftwsiqqxv[] = { 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16};
static const int8_t gdihjixljmdk[] = { 16-10, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 24-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t bmfzssirrupa[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t ryfrvvfnrfrb[] = { 16-16, 16-16, 16-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16, 30-16};
static const int8_t jdmxilbrudfr[] = { 16-16, 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 27-16, 28-16, 29-16, 30-16, 30-16, 30-16};
static const uint8_t xzknmramwbri[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t imzgopzzntfw[] = { 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t ejklwvfeuacn[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t ctcmtduzjcwa[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t fekohfvtqoog[] = { 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d};
static const uint8_t cujqtatlweve[] = { 0x60, 0x61, 0x62, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69, 0x70, 0x71, 0x72, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 0x80, 0x81, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88};
static const uint8_t hsfdeqyfixya[] = { 0, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t xveklikwzngn[] = { 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20};
static const uint8_t rihtzihpeasn[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0};
static const uint8_t fqvavjyqvuxn[] = { 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18};
static const uint8_t rswirnxvhmwj[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t zqtcqpoyakyt[] = { 0x3D, 0x3D, 0x3E, 0x3F, 0x40, 0x41, 0x42, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48, 0x49, 0x4A, 0x4B, 0x4C, 0x4D, 0x4E, 0x4F, 0x50, 0x51, 0x52, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58};
static const uint8_t inhynngxkhtf[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t xnsuucjkgiyf[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 1};
static const uint8_t vxbaadsvabah[] = { 0X79, 0x7B, 0x7D, 0x7F, 0x81, 0x83, 0x85, 0x87, 0x89, 0x8B, 0x8D, 0x8F, 0x91, 0x93, 0x95, 0x97, 0x99, 0x9B, 0x9D, 0x9F, 0xA1, 0xA3, 0xA5, 0xA7, 0xA9, 0xAB, 0xAD, 0xAF, 0xB1};
static const uint8_t qxlfjmiwdkuk[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t gmbljbtnmbmf[] = { 0x1c, 0x1d, 0x1e, 0x1f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18};
static const uint8_t ynftufkflmwk[] = { 0x01, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x05};
static const uint8_t hhxoyyigbord[] = { 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t ynttzckzhzlm[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t njggjrodojst[] = { 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0x0f};
static const uint8_t loxykwzfxjno[] = { 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t kmhnniqflzou[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t waxlzigehcxd[] = { 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5};
static const uint8_t fruhbgbeivcj[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const struct yibohltnjvlz ogxrkxpsvrkj = { bsucdezhduxa, { 0, 1, 0x40, 6, xzknmramwbri } };
static const struct yibohltnjvlz tsubxikehlyo = { cwdqxraiphdw, { 0, 3, 0x04, 2, imzgopzzntfw } };
static const struct yibohltnjvlz yqcljgihltxd = { ysaaperdhlmr, { 0, 1, 0x01, 0, ctcmtduzjcwa } };
static const struct yibohltnjvlz nwtxnitqmkzb = { ysaaperdhlmr, { 0, 2, 0x01, 0, ctcmtduzjcwa } };
static const struct yibohltnjvlz levrxybwiqno = { lvormwsqmqjw, { 1, 2, 0x01, 0, rihtzihpeasn } };
static const struct yibohltnjvlz pesaoochqbkt = { bsucdezhduxa, { 0, 10, 0x01, 0, xzknmramwbri } };
static const struct yibohltnjvlz sfehycqllmim = { cwdqxraiphdw, { 0, 3, 0x1F, 0, fekohfvtqoog } };
static const struct yibohltnjvlz derhlbxyjkaq = { bsucdezhduxa, { 1, 3, 0xFF, 0, cujqtatlweve } };
static const struct yibohltnjvlz fgjdpnnbjdzl = { jhrfmjzzwnqw, { 0, 0, 0, 0, NULL } };
static const struct yibohltnjvlz pmwszizmljxs = { hpfblzemcdow, { 3, 6, 0x01, 0, ejklwvfeuacn } };
static const struct yibohltnjvlz wsgdrhxlewqi = { wyzierxyvrke, { 0, 0, 0, 0, NULL } };
static const struct yibohltnjvlz wdpzrbawyaeh = { ysaaperdhlmr, { 1, 10, 0x01, 0, ctcmtduzjcwa } };
static const struct yibohltnjvlz zycyzppwoguf = { hpfblzemcdow, { 1, 6, 0x01, 0, ejklwvfeuacn } };
static const struct yibohltnjvlz dakwrsmftmti = { hpfblzemcdow, { 2, 6, 0x01, 0, ejklwvfeuacn } };
static const struct yibohltnjvlz kjrvixocpywt = { kcgzjnswcxyo, { 0, 12, 0x04, 2, hsfdeqyfixya } };
static const struct yibohltnjvlz awfglgyaukwx = { ysaaperdhlmr, { 1, 1, 0x04, 2, ctcmtduzjcwa } };
static const struct yibohltnjvlz yioyrieypquj = { ysaaperdhlmr, { 0, 10, 0x02, 1, ctcmtduzjcwa } };
static const struct yibohltnjvlz jenyyyjfprpf = { gzajhisgktow, { 0, 8, 0x01, 0, ctcmtduzjcwa } };
static const struct yibohltnjvlz sewqpovuqhmk = { cwdqxraiphdw, { 0, 10, 0x3e, 1, xveklikwzngn } };
static const struct yibohltnjvlz ueeykihfhczt = { ysaaperdhlmr, { 0, 7, 0x01, 0, ctcmtduzjcwa } };
static const struct yibohltnjvlz vncxgoxnufyo = { ysaaperdhlmr, { 1, 0, 0x01, 0, ctcmtduzjcwa } };
static const struct yibohltnjvlz bmoqnftmravx = { cwdqxraiphdw, { 0, 12, 0x1f, 0, fqvavjyqvuxn } };
static const struct yibohltnjvlz jfkhlpharckt = { gzajhisgktow, { 0, 7, 0x01, 0, rihtzihpeasn } };
static const struct yibohltnjvlz cpgzscnqcwln = { pcxfqfrcrtht, { 0, 0, 0, 0, NULL } };
static const struct yibohltnjvlz mqjxhpdfkogx = { gzajhisgktow, { 0, 9, 0x01, 0, rswirnxvhmwj } };
static const struct yibohltnjvlz zgdshureeylg = { ysaaperdhlmr, { 0, 3, 0x01, 0, ctcmtduzjcwa } };
static const struct yibohltnjvlz nxvwddljsssp = { kcgzjnswcxyo, { 0, 11, 0x7F, 0, zqtcqpoyakyt } };
static const struct yibohltnjvlz hhdbovujarvl = { ysaaperdhlmr, { 0, 0, 0x01, 0, ctcmtduzjcwa } };
static const struct yibohltnjvlz kanbxgrimqos = { gzajhisgktow, { 0, 2, 0x01, 0, rswirnxvhmwj } };
static const sgqtcddyvqhi oxhnktvsxzso[2] = { { 0, 7, 0x04, 2, inhynngxkhtf }, { 0, 1, 0x01, 0, loxykwzfxjno } };
static const struct yibohltnjvlz xtmvrhflocpb = { gzajhisgktow, { 0x10, 0, 0, 2, (const uint8_t*)oxhnktvsxzso } };
static const struct yibohltnjvlz rtbpdhogkzei = { hpfblzemcdow, { 2, 2, 0x20, 5, ejklwvfeuacn } };
static const struct yibohltnjvlz hijcteziksza = { hpfblzemcdow, { 2, 3, 0x80, 7, ejklwvfeuacn } };
static const struct yibohltnjvlz zmohcgknxaxm = { grmfayntgkol, { 1, 12, 0x01, 0, xnsuucjkgiyf } };
static const struct yibohltnjvlz frdjidlpedio = { bsucdezhduxa, { 1, 4, 0x01, 0, xzknmramwbri } };
static const struct yibohltnjvlz lxeqpmwhdsih = { kcgzjnswcxyo, { 0, 11, 0xff, 0, vxbaadsvabah } };
static const struct yibohltnjvlz tuctowhqdgtw = { dulqjsjbglpm, { 2, 3, 0x80, 7, qxlfjmiwdkuk } };
static const struct yibohltnjvlz lyouxofyxgly = { cwdqxraiphdw, { 0, 12, 0x1f, 0, gmbljbtnmbmf } };
static const struct yibohltnjvlz ikpnyldpmuuy = { kcgzjnswcxyo, { 1, 12, 0x04, 2, hsfdeqyfixya } };
static const struct yibohltnjvlz ssbdydnaatik = { ytvijahfvzzx, { 1, 2, 0xf0, 4, ynftufkflmwk } };
static const struct yibohltnjvlz fihultrelcxx = { gzajhisgktow, { 0, 7, 0x10, 4, rswirnxvhmwj } };
static const struct yibohltnjvlz geexgwgzyaii = { gzajhisgktow, { 0, 0, 0, 0, NULL } };
static const struct yibohltnjvlz ddkuvswepyou = { qzdreliieqwj, { 0, 0, 0, 0, NULL } };
static const struct yibohltnjvlz ituhechfmvhy = { ocpftwsiqqxv, { 1, 5, 0x01, 0, hhxoyyigbord } };
static const struct yibohltnjvlz utjxvatgxgsc = { kcgzjnswcxyo, { 0, 9, 0x40, 6, hsfdeqyfixya } };
static const struct yibohltnjvlz rhzkmpegvlsw = { gzajhisgktow, { 1, 0, 0x01, 0, rswirnxvhmwj } };
static const struct yibohltnjvlz gcfiyuhrkzvo = { ocpftwsiqqxv, { 1, 7, 0x10, 4, hhxoyyigbord } };
static const struct yibohltnjvlz mpsippkzoqot = { cwdqxraiphdw, { 0, 0, 0, 0, NULL } };
static const struct yibohltnjvlz vejsakfloial = { gdihjixljmdk, { 0, 0, 0, 0, NULL } };
static const struct yibohltnjvlz nhlnkdhhbpnm = { ytvijahfvzzx, { 0, 0, 0, 0, NULL } };
static const struct yibohltnjvlz wlqancmfqcej = { gzajhisgktow, { 3, 3, 0x01, 0, rswirnxvhmwj } };
static const struct yibohltnjvlz dwxuoqwpdnuk = { bmfzssirrupa, { 0, 4, 0x01, 0, ynttzckzhzlm } };
static const struct yibohltnjvlz trqvcxreynbl = { cwdqxraiphdw, { 0, 5, 0x0f, 0, njggjrodojst } };
static const struct yibohltnjvlz nnndecoqlrsb = { ysaaperdhlmr, { 0, 3, 0x01, 0, rswirnxvhmwj } };
static const struct yibohltnjvlz ofimmufgbfjt = { ysaaperdhlmr, { 1, 3, 0x01, 0, rihtzihpeasn } };
static const struct yibohltnjvlz znbhexqwyyix = { ryfrvvfnrfrb, { 0, 0, 0, 0, NULL } };
static const struct yibohltnjvlz bvpsdmkepzbc = { gzajhisgktow, { 0, 13, 0x01, 0, rihtzihpeasn } };
static const struct yibohltnjvlz zknvqcxtnhxh = { lvormwsqmqjw, { 0, 0, 0x01, 0, rihtzihpeasn } };
static const struct yibohltnjvlz sraexlzzubpr = { gzajhisgktow, { 0, 1, 0x01, 0, rswirnxvhmwj } };
static const struct yibohltnjvlz offkkhbxnicg = { ysaaperdhlmr, { 1, 1, 0x10, 4, ctcmtduzjcwa } };
static const struct yibohltnjvlz tthkoixletsg = { lvormwsqmqjw, { 0, 3, 0x01, 0, rihtzihpeasn } };
static const struct yibohltnjvlz scceroynzfgz = { lvormwsqmqjw, { 0, 2, 0x08, 3, rihtzihpeasn } };
static const struct yibohltnjvlz kaduikdcfhdi = { kcgzjnswcxyo, { 2, 3, 0x80, 7, hsfdeqyfixya } };
static const sgqtcddyvqhi glyzgpoasjes[2] = { { 0, 4, 0x80, 7, inhynngxkhtf }, { 0, 5, 0x01, 0, loxykwzfxjno } };
static const struct yibohltnjvlz mqajuwzrmobl = { gzajhisgktow, { 0x10, 0, 0, 2, (const uint8_t*)glyzgpoasjes } };
static const struct yibohltnjvlz acjfdujbczqe = { lvormwsqmqjw, { 0, 3, 0x04, 2, rihtzihpeasn } };
static const struct yibohltnjvlz tcozbxwdupxg = { lvormwsqmqjw, { 0, 1, 0x01, 0, rihtzihpeasn } };
static const sgqtcddyvqhi tzhudcoorpgt[2] = { { 0, 2, 0x08, 3, kmhnniqflzou }, { 0, 2, 0x10, 4, rswirnxvhmwj } };
static const struct yibohltnjvlz lgtnyzkrnwsw = { gzajhisgktow, { 0x10, 0, 0, 2, (const uint8_t*)tzhudcoorpgt } };
static const sgqtcddyvqhi jhehtysmnpff[2] = { { 1, 0, 0x0F, 0, waxlzigehcxd }, { 1, 0, 0x10, 4, rihtzihpeasn } };
static const struct yibohltnjvlz nqclnibzqbfj = { lvormwsqmqjw, { 0x10, 0, 0, 2, (const uint8_t*)jhehtysmnpff } };
static const struct yibohltnjvlz mdtnuewmwfod = { lvormwsqmqjw, { 1, 1, 0x01, 0, rihtzihpeasn } };
static const struct yibohltnjvlz zfxcractzbdd = { gzajhisgktow, { 0, 1, 0x08, 3, loxykwzfxjno } };
static const struct yibohltnjvlz xddxzbwkgxzf = { hpfblzemcdow, { 3, 6, 0x02, 1, ejklwvfeuacn } };
static const struct yibohltnjvlz rhycpdaodrak = { ysaaperdhlmr, { 3, 6, 0x01, 0, ctcmtduzjcwa } };
static const struct yibohltnjvlz secivibyrhrv = { jdmxilbrudfr, { 0, 3, 0x04, 2, fruhbgbeivcj } };
static const struct yibohltnjvlz gculcshoavsy = { bsucdezhduxa, { 0, 0, 0, 0, NULL } };
static const struct odxfhxsrevig avgpczlxrbwq = { 0x00, 1, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct odxfhxsrevig vtqylmvupfua = { 0x11, 0, -3, 2, {0, 1, 0, 0}, 1, -1, 0, 0 };
static const struct odxfhxsrevig wzjijutorrrx = { 0x22, 1, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct odxfhxsrevig nlxivazyoxqs = { 0x33, 0, -3, 2, {0, 1, 0, 0}, 3, -1, 0, 0 };
static const struct odxfhxsrevig ctbgzfoovnmy = { 0x00, 0, -3, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct odxfhxsrevig dvdmlmaedyvz = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 1, 0xff };
static const struct odxfhxsrevig ekcbxtuytzpp = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 1, 0xff };
static const struct odxfhxsrevig jyucovsshrtm = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct odxfhxsrevig mumzefbliysr = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 0, 0x0 };
static const struct odxfhxsrevig zmgjfsartzrg = { 0x22, 0, -1, 1, {0, 0, 0, 0}, 2, 0, 0, 0x0 };
static const struct odxfhxsrevig ogdwmrtodywa = { 0x33, 0, -1, 1, {0, 0, 0, 0}, 3, 0, 0, 0x0 };
static const struct odxfhxsrevig pvybvmlhuloz = { 0x00, 0, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct odxfhxsrevig wzzbshdvmfuy = { 0x11, 0, -1, 2, {1, 0, 0, 1}, 1, 1, 0xff, 0xff };
static const struct odxfhxsrevig reklrsfthlqw = { 0x22, 0, -1, 2, {1, 0, 0, 1}, 2, 1, 0xff, 0xff };
static const struct odxfhxsrevig gkfkzbhbntcg = { 0x00, 0, -2, 4, {1, 0, 0, 1}, 0, 2, 0xff, 0xff };
static const struct odxfhxsrevig prjsqoervehw = { 0x00, 1, -2, 4, {1, 0, 0, 1}, 0, 2, 0xff, 0xff };
static const struct odxfhxsrevig qgnkicdtdjtq = { 0x00, 0, -1, 2, {0, 0, 0, 1}, 0, 1, 0xff, 0 };
static const struct odxfhxsrevig pcsggpxumorz = { 0x22, 0, -1, 2, {0, 0, 0, 1}, 2, 1, 0xff, 0 };
static const struct odxfhxsrevig eoaveuljorsc = { 0x00, 0, -1, 1, {1, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct odxfhxsrevig bvgsrfdaydut = { 0x11, 0, -1, 1, {1, 0, 0, 0}, 1, 0, 0, 0x0 };
static const struct odxfhxsrevig zrbeksiaauky = { 0x22, 0, -1, 1, {1, 0, 0, 0}, 2, 0, 0, 0x0 };
static const struct odxfhxsrevig wfawmwqcuspd = { 0x00, 0, 0, 1, {0, 0, 0, 1}, 1, 0, 0xff, 0 };
static const struct odxfhxsrevig vjstgznvwkvu = { 0x11, 0, 0, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct odxfhxsrevig alzfyujzjwcb = { 0x22, 0, 0, 1, {0, 0, 0, 1}, 3, 0, 0xff, 0 };
static const struct odxfhxsrevig uxqoceajjrhy = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0x0 };
static const struct odxfhxsrevig vxrpbzvexhrm = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0xf8 };
static const struct odxfhxsrevig hldklijxxexy = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0xf2 };
static const struct odxfhxsrevig khwqelqibjwa = { 0x11, 0, -2, 1, {0, 0, 1, 0}, 1, 0, 0, 0x0 };
static const struct odxfhxsrevig mazbmjtuzyie = { 0x00, 1, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct odxfhxsrevig odecbjoijkbz = { 0, 0, (int8_t)0xff, 0, {6, 0, 0, 0}, 0, 3, 0, 0xff };
static const struct odxfhxsrevig yehmpojxaybd = { 0, 0, (int8_t)0xff, 0, {6, 0, 0, 0}, 0, 4, 0, 0xff };
static const struct odxfhxsrevig ecwsiyxkzwaj = { 0, 0, (int8_t)0xff, 0, {0, 0, 0, 0}, 0, 4, 0, 0xff };
static const struct odxfhxsrevig pxcthaugizff = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x0 };
static const struct odxfhxsrevig hljmghobgwjh = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x02 };
static const struct odxfhxsrevig guttmqjdzztj = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x0 };
static const struct odxfhxsrevig wzvjteoofidy = { 0x00, 3, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct odxfhxsrevig ekpmrgjgttgm = { 0x11, 3, -1, 2, {1, 0, 0, 1}, 1, 1, 0xff, 0xff };
static const struct odxfhxsrevig vgxwwjmzlozo = { 0x22, 3, -1, 2, {1, 0, 0, 1}, 2, 1, 0xff, 0xff };
static const struct odxfhxsrevig vsfygykqnfhs = { 0x00, 1, -1, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct odxfhxsrevig ftfdyiztnffs = { 0x00, 0, 0, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct odxfhxsrevig djcxhrpzehlx = { 0x22, 0, 0, 1, {1, 0, 0, 1}, 3, 0, 0xff, 0xff };
static const struct odxfhxsrevig ihkvuvwwmaoy = { 0x00, 0, 0, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct odxfhxsrevig blljvzcyahvn = { 0x11, 0, 0, 1, {0, 0, 0, 1}, 3, 0, 0xff, 0 };
static const struct odxfhxsrevig iwetjklniele = { 0x11, 0, 0, 1, {1, 0, 0, 1}, 2, 0, 0xff, 0xff };
static const struct odxfhxsrevig lywpkgsfeoan = { 0x00, 5, -10, 1, {0, 0, 1, 0}, 0, -4, 0, 0x0 };
static const struct odxfhxsrevig jionkjspwepo = { 0x00, 5, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0x0 };
static const struct odxfhxsrevig zsedxjqpkfoj = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 6, 0x0 };
static const struct odxfhxsrevig trzetqkqfqll = { 0x00, 0, -1, 1, {6, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct odxfhxsrevig xhgmhhmaarkg = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 3 };
static const struct odxfhxsrevig kxvdrrjgucdv = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0xfe };
static const struct odxfhxsrevig avzogjnpxjfr = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x08 };
static const struct odxfhxsrevig febmmdqityha = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x88 };
static const struct odxfhxsrevig gtayfnojknju = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x0f };
static const struct odxfhxsrevig aqjcqimumnut = { 2, 0, 0x1f, 0, {0, 0, 0, 0}, 0, 3, 0, 0x1f };
static const struct odxfhxsrevig glaxzgdaenfe = { 0x00, 0, -1, 1, {10, 0, 0, 0}, 0, 0, 0, 0 };
static const struct odxfhxsrevig yyegkcuvybka = { 0x00, 0, -3, 1, {0, 0, 0, 1}, 1, 4, 0xff, 0 };
static const struct odxfhxsrevig htbjievjghdk = { 0x11, 8, -9, 1, {0, 0, 0, 1}, 2, -2, 0xff, 0 };
static const struct odxfhxsrevig xqreyxaqdvur = { 0x11, 0, -13, 2, {0, 1, 0, 0}, 1, -11, 0, 0 };
static const struct odxfhxsrevig efwghxmlbhmm = { 0x11, 9, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct odxfhxsrevig axceitcecroz = { 0x22, 0, -13, 2, {0, 1, 0, 0}, 2, -11, 0, 0 };
static const struct odxfhxsrevig jjdfqpvvswos = { 0x00, 0, 0, 1, {0, 0, 0, 0}, 1, -1, 0, 0 };
static const struct odxfhxsrevig rjkssbndhjdi = { 0x00, 4, -1, 1, {1, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct odxfhxsrevig euwgnuoqzhyv = { 0x00, 0, -1, 1, {12, 0, 0, 0}, 0, 0, 11, 0x0 };
static const struct odxfhxsrevig lookktbgeqsm = { 0x00, 0, -1, 1, {13, 0, 0, 0}, 0, 0, 4, 2 };
static const struct odxfhxsrevig fbhvpwohrmrx = { 0x00, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 0, 0x0 };
static const struct odxfhxsrevig ioxlywhilklj = { 0x22, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 0, 0x0 };
static const struct odxfhxsrevig mggpajjlcjde = { 0x11, 1, 0, 1, {13, 1, 0, 0}, 1, -5, 1, 0xFF };
static const struct odxfhxsrevig uesjuuepzgkm = { 0x33, 1, 0, 1, {13, 1, 0, 0}, 3, -5, 1, 0xFF };
static const struct odxfhxsrevig eqitoovrxyqd = { 0x00, 0, -1, 1, {6, 0, 0, 0}, -1, 0, 0, 0x7f };
static const struct odxfhxsrevig bpvijyotlmvf = { 0x00, 0xff, 0, 1, {0, 1, 0, 0}, 0, 0, 1, 0x2c };
static const struct odxfhxsrevig wnjibhmtfdhu = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 1, 0xaa };
static const struct odxfhxsrevig sdfqwvcxeyas = { 0x11, 1, 0, 1, {1, 0, 0, 1}, 0, 0, 0xff, 0xff };
#ifndef _NO_DEPRECATED
static const struct odxfhxsrevig ljhgmhnbrgdm = { 0, 0, 3, 0, {0, 0, 0, 0}, 0, 0, 0, 0 };
static const struct odxfhxsrevig zcxjbkpetgso = { 0, 0, 8, 0, {0, 0, 0, 0}, 0, 0, 0, 0 };
#endif
static const struct odxfhxsrevig rmibxbstxgsf = { 0x00, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 4, 7 };
static const struct odxfhxsrevig vazrfvrkbapt = { 0x00, 0xff, -1, 1, {0, 1, 0, 0}, 1, 0, 1, 0x80 };
static const struct odxfhxsrevig chfiflxfbslt = { 0x00, 0, -1, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct odxfhxsrevig lpwefxlnruwb = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 0, 0x09 };
static const struct odxfhxsrevig ykjdmwnxjdyy = { 0x22, 0, -1, 1, {0, 0, 0, 0}, 2, 0, 0, 0xF1 };
static const struct odxfhxsrevig bpxcimpdmgyd = { 0x11, 0, 0, 1, {0, 0, 0, 0}, 0, -1, 0, 0 };
static const struct odxfhxsrevig nohalqadttgm = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x54 };
static const struct odxfhxsrevig jogwgmcwqmjd = { 0x11, 0, 0, 1, {15, 0, 0, 0}, -1, 0, 0, 0 };
static const struct odxfhxsrevig ocifnmnhwcuz = { 0x00, 0, 0, 1, {0, 1, 0, 0}, 2, 0, 15, 0x0 };
static const struct odxfhxsrevig ygifszwxncyq = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0xed };
static const struct odxfhxsrevig yzemreiddrni = { 0x00, 0, -1, 1, {1, 0, 0, 0}, 1, 0, 0, 0x14 };
static const struct rkmkqkradcrt buhbaxchubft[] = { { puznxqrbhbkt,	&ctbgzfoovnmy }, { fvectlrkjgcy,	&avgpczlxrbwq }, { fvectlrkjgcy,	&vtqylmvupfua }, { fvectlrkjgcy,	&wzjijutorrrx }, { fvectlrkjgcy,	&nlxivazyoxqs }, {NULL, NULL} };
static const struct rkmkqkradcrt npahjdskfqoc[] = { { fvectlrkjgcy,	&avgpczlxrbwq }, { fvectlrkjgcy,	&vtqylmvupfua }, { fvectlrkjgcy,	&wzjijutorrrx }, { fvectlrkjgcy,	&nlxivazyoxqs }, {NULL, NULL} };
static const struct rkmkqkradcrt aqjqvbpvfzav[] = { { fvectlrkjgcy,	&avgpczlxrbwq }, { fvectlrkjgcy,	&vtqylmvupfua }, {NULL, NULL} };
static const struct rkmkqkradcrt bbraenilafou[] = { { puznxqrbhbkt,	&dvdmlmaedyvz }, {NULL, NULL} };
static const struct rkmkqkradcrt gjczrrnciugo[] = { { fvectlrkjgcy,	&dvdmlmaedyvz }, {NULL, NULL} };
static const struct rkmkqkradcrt wpbbehpommlp[] = { { puznxqrbhbkt,	&jyucovsshrtm }, {NULL, NULL} };
static const struct rkmkqkradcrt wakpzpggevwl[] = { { puznxqrbhbkt,	&jyucovsshrtm }, { puznxqrbhbkt,	&mumzefbliysr }, {NULL, NULL} };
static const struct rkmkqkradcrt preizmuhmxgq[] = { { puznxqrbhbkt,	&mumzefbliysr }, { puznxqrbhbkt,	&zmgjfsartzrg }, { puznxqrbhbkt,	&ogdwmrtodywa }, {NULL, NULL} };
static const struct rkmkqkradcrt jlledcdowuhe[] = { {NULL, NULL} };
static const struct rkmkqkradcrt nxeyakvojjes[] = { { puznxqrbhbkt, &eoaveuljorsc}, { puznxqrbhbkt, &wfawmwqcuspd}, {NULL, NULL} };
static const struct rkmkqkradcrt fqmqmhxzkuiy[] = { { fvectlrkjgcy,	&uxqoceajjrhy }, {NULL, NULL} };
static const struct rkmkqkradcrt ifbevdpuzizy[] = { { fvectlrkjgcy,	&khwqelqibjwa }, {NULL, NULL} };
static const struct rkmkqkradcrt regrxaxnulwm[] = { { puznxqrbhbkt, &pvybvmlhuloz }, { puznxqrbhbkt, &wfawmwqcuspd}, {NULL, NULL} };
static const struct rkmkqkradcrt jlwtbfzaxhsq[] = { { puznxqrbhbkt,	&ygifszwxncyq }, { puznxqrbhbkt,	&mumzefbliysr }, {NULL, NULL} };
static const struct rkmkqkradcrt gtjjaygnutej[] = { { puznxqrbhbkt,	&gtayfnojknju }, { puznxqrbhbkt,	&mumzefbliysr }, {NULL, NULL} };
static const struct rkmkqkradcrt flpszvfgkfpq[] = { { puznxqrbhbkt, &pvybvmlhuloz }, {NULL, NULL} };
static const struct rkmkqkradcrt babjaboxqjtq[] = { { lluxgncggttr,	&jyucovsshrtm }, {NULL, NULL} };
static const struct rkmkqkradcrt arfkjqielkhb[] = { { lluxgncggttr,	&jyucovsshrtm }, { lluxgncggttr,	&mumzefbliysr }, {NULL, NULL} };
static const struct rkmkqkradcrt oevgixouztwt[] = { { fvectlrkjgcy,	&uxqoceajjrhy }, { puznxqrbhbkt, &wfawmwqcuspd}, {NULL, NULL} };
static const struct rkmkqkradcrt yrtrkmxqktlt[] = { { puznxqrbhbkt, &qgnkicdtdjtq}, { puznxqrbhbkt, &pcsggpxumorz}, { puznxqrbhbkt, &wfawmwqcuspd}, { puznxqrbhbkt, &alzfyujzjwcb}, {NULL, NULL} };
static const struct rkmkqkradcrt qdwpcydhuyly[] = { { puznxqrbhbkt, &eoaveuljorsc}, {NULL, NULL} };
static const struct rkmkqkradcrt tayqfyoxkksz[] = { { puznxqrbhbkt, &pvybvmlhuloz}, { puznxqrbhbkt, &wfawmwqcuspd}, { puznxqrbhbkt, &zmgjfsartzrg}, {NULL, NULL} };
static const struct rkmkqkradcrt ugoquwtumcry[] = { { puznxqrbhbkt, &pvybvmlhuloz}, { puznxqrbhbkt, &wfawmwqcuspd}, {NULL, NULL} };
static const struct rkmkqkradcrt smrjemyxbsko[] = { { puznxqrbhbkt, &mazbmjtuzyie}, {NULL, NULL} };
static const struct rkmkqkradcrt bqkgazqwpcci[] = { { fvectlrkjgcy,	&uxqoceajjrhy }, { puznxqrbhbkt, &wfawmwqcuspd}, {NULL, NULL} };
static const struct rkmkqkradcrt xbgrirfpgybc[] = { { puznxqrbhbkt, &wfawmwqcuspd}, {NULL, NULL} };
static const struct rkmkqkradcrt ybnpeclipoez[] = { { lluxgncggttr,	&dvdmlmaedyvz }, {NULL, NULL} };
static const struct rkmkqkradcrt ydbrzideejmo[] = { { sclhjmnqibbk,	&odecbjoijkbz }, { puznxqrbhbkt,	&jyucovsshrtm }, {NULL, NULL} };
static const struct rkmkqkradcrt ioevhtzcnyea[] = { { sclhjmnqibbk,	&yehmpojxaybd }, { puznxqrbhbkt,	&jyucovsshrtm }, {NULL, NULL} };
static const struct rkmkqkradcrt oylrrdvgjqxg[] = { { sclhjmnqibbk,	&ecwsiyxkzwaj }, { puznxqrbhbkt,	&jyucovsshrtm }, {NULL, NULL} };
static const struct rkmkqkradcrt abjpqmkybtzk[] = { { puznxqrbhbkt, &ftfdyiztnffs}, {NULL, NULL} };
static const struct rkmkqkradcrt zsgropnvkcoz[] = { { puznxqrbhbkt, &ftfdyiztnffs}, { puznxqrbhbkt, &djcxhrpzehlx}, {NULL, NULL} };
static const struct rkmkqkradcrt vwseaoclbrqg[] = { { fvectlrkjgcy,	&vxrpbzvexhrm }, {NULL, NULL} };
static const struct rkmkqkradcrt gogvzhwuapbb[] = { { fvectlrkjgcy,	&hldklijxxexy }, {NULL, NULL} };
static const struct rkmkqkradcrt wrarviifhafn[] = { { fvectlrkjgcy,	&pxcthaugizff }, {NULL, NULL} };
static const struct rkmkqkradcrt zkbzupvwkovr[] = { { fvectlrkjgcy,	&hljmghobgwjh }, {NULL, NULL} };
static const struct rkmkqkradcrt pqgspokxpjpv[] = { { puznxqrbhbkt,	&bvgsrfdaydut }, { puznxqrbhbkt,	&zrbeksiaauky }, {NULL, NULL} };
static const struct rkmkqkradcrt bspdaeureyvl[] = { { puznxqrbhbkt,	&mumzefbliysr }, {NULL, NULL} };
static const struct rkmkqkradcrt wtzqzrgdbyvn[] = { { puznxqrbhbkt, &bvgsrfdaydut}, {NULL, NULL} };
static const struct rkmkqkradcrt tmpyrvtulwjk[] = { { puznxqrbhbkt, &wzzbshdvmfuy}, {NULL, NULL} };
static const struct rkmkqkradcrt isrkkhepioxo[] = { { puznxqrbhbkt, &guttmqjdzztj}, {NULL, NULL} };
static const struct rkmkqkradcrt swahqnbgddbn[] = { { puznxqrbhbkt, &wzvjteoofidy}, { puznxqrbhbkt, &ekpmrgjgttgm}, { puznxqrbhbkt, &vgxwwjmzlozo}, {NULL, NULL} };
static const struct rkmkqkradcrt ozuzhfdydbgr[] = { { fvectlrkjgcy, &vsfygykqnfhs}, { puznxqrbhbkt, &ihkvuvwwmaoy}, {NULL, NULL} };
static const struct rkmkqkradcrt yozquwuvvduy[] = { { puznxqrbhbkt,	&jyucovsshrtm }, { puznxqrbhbkt, &wfawmwqcuspd}, {NULL, NULL} };
static const struct rkmkqkradcrt vbmxdzxbjosn[] = { { puznxqrbhbkt, &iwetjklniele}, {NULL, NULL} };
static const struct rkmkqkradcrt liluzfedrafi[] = { { lluxgncggttr,	&lywpkgsfeoan }, { lluxgncggttr,	&jionkjspwepo }, {NULL, NULL} };
static const struct rkmkqkradcrt nuszhkpvkapz[] = { { puznxqrbhbkt, &qgnkicdtdjtq}, { puznxqrbhbkt, &wfawmwqcuspd}, { puznxqrbhbkt, &vjstgznvwkvu}, {NULL, NULL} };
static const struct rkmkqkradcrt cxtrtpjnxbgx[] = { { lluxgncggttr,	&jionkjspwepo }, {NULL, NULL} };
static const struct rkmkqkradcrt laxvqrktwdxt[] = { { puznxqrbhbkt, &zsedxjqpkfoj}, {NULL, NULL} };
static const struct rkmkqkradcrt lsfwjlkhaxkl[] = { { puznxqrbhbkt, &trzetqkqfqll}, {NULL, NULL} };
static const struct rkmkqkradcrt cahpkfeydkxz[] = { { puznxqrbhbkt, &wzzbshdvmfuy }, {NULL, NULL} };
static const struct rkmkqkradcrt lkgfpruratxp[] = { { puznxqrbhbkt, &ekcbxtuytzpp }, {NULL, NULL} };
static const struct rkmkqkradcrt tsdqbxzeriog[] = { { puznxqrbhbkt, &xhgmhhmaarkg }, {NULL, NULL} };
static const struct rkmkqkradcrt vwyexfmkybys[] = { { puznxqrbhbkt, &febmmdqityha }, {NULL, NULL} };
static const struct rkmkqkradcrt vlgwouoxxcaa[] = { { puznxqrbhbkt, &mumzefbliysr }, { puznxqrbhbkt, &zmgjfsartzrg }, {NULL, NULL} };
static const struct rkmkqkradcrt ggdszwtxsgur[] = { { lluxgncggttr, &kxvdrrjgucdv }, {NULL, NULL} };
static const struct rkmkqkradcrt fdgzrisjvsnx[] = { { sclhjmnqibbk,	&aqjcqimumnut }, { puznxqrbhbkt, &ftfdyiztnffs}, { puznxqrbhbkt, &ihkvuvwwmaoy}, {NULL, NULL} };
static const struct rkmkqkradcrt gczqerlgwjae[] = { { lluxgncggttr, &avzogjnpxjfr }, {NULL, NULL} };
static const struct rkmkqkradcrt rgjakmryrrwd[] = { { sclhjmnqibbk,	&aqjcqimumnut }, {NULL, NULL} };
static const struct rkmkqkradcrt yslsxyjazcti[] = { { fvectlrkjgcy,	&khwqelqibjwa }, { puznxqrbhbkt, &ihkvuvwwmaoy}, { puznxqrbhbkt, &blljvzcyahvn}, {NULL, NULL} };
static const struct rkmkqkradcrt cuspzgwykqdl[] = { { puznxqrbhbkt,	&dvdmlmaedyvz }, { puznxqrbhbkt, &wfawmwqcuspd}, {NULL, NULL} };
static const struct rkmkqkradcrt cljvrzgwybyf[] = { { puznxqrbhbkt,	&glaxzgdaenfe }, {NULL, NULL} };
static const struct rkmkqkradcrt mvkmtnkrwpfm[] = { { puznxqrbhbkt, &ihkvuvwwmaoy}, { puznxqrbhbkt, &blljvzcyahvn}, {NULL, NULL} };
static const struct rkmkqkradcrt ltxohdptrmwi[] = { { puznxqrbhbkt, &pvybvmlhuloz}, { puznxqrbhbkt, &wfawmwqcuspd}, {puznxqrbhbkt, &reklrsfthlqw}, {NULL, NULL} };
static const struct rkmkqkradcrt wnvjgyeegfkz[] = { { fvectlrkjgcy, &jyucovsshrtm }, {NULL, NULL} };
static const struct rkmkqkradcrt wsqjfycjhjhm[] = { { puznxqrbhbkt, &gkfkzbhbntcg}, { puznxqrbhbkt, &prjsqoervehw}, {NULL, NULL} };
static const struct rkmkqkradcrt ucewadkrfpts[] = { { puznxqrbhbkt,	&yyegkcuvybka }, { fvectlrkjgcy,	&avgpczlxrbwq }, { fvectlrkjgcy,	&xqreyxaqdvur }, { fvectlrkjgcy,	&efwghxmlbhmm }, { fvectlrkjgcy,	&axceitcecroz }, {NULL, NULL} };
static const struct rkmkqkradcrt lrzvihwysyju[] = { { zigckxbdzdvg, &jjdfqpvvswos}, {NULL, NULL} };
static const struct rkmkqkradcrt tvgktsaxfjel[] = { { puznxqrbhbkt, &jjdfqpvvswos}, {NULL, NULL} };
static const struct rkmkqkradcrt kwntolvtjejo[] = { { puznxqrbhbkt, &rjkssbndhjdi}, { puznxqrbhbkt, &wfawmwqcuspd}, { puznxqrbhbkt, &alzfyujzjwcb}, {NULL, NULL} };
static const struct rkmkqkradcrt trsviwrdgzmk[] = { { puznxqrbhbkt, &euwgnuoqzhyv}, { puznxqrbhbkt, &ftfdyiztnffs}, {NULL, NULL} };
static const struct rkmkqkradcrt sypsknquhmzz[] = { { puznxqrbhbkt, &fbhvpwohrmrx}, { puznxqrbhbkt, &mggpajjlcjde}, { puznxqrbhbkt, &ioxlywhilklj}, { puznxqrbhbkt, &uesjuuepzgkm}, {NULL, NULL} };
static const struct rkmkqkradcrt moagfmqignav[] = { { puznxqrbhbkt, &fbhvpwohrmrx}, { puznxqrbhbkt, &mggpajjlcjde}, { puznxqrbhbkt, &fbhvpwohrmrx}, { puznxqrbhbkt, &uesjuuepzgkm}, {NULL, NULL} };
static const struct rkmkqkradcrt uviddcgaqelg[] = { { puznxqrbhbkt, &fbhvpwohrmrx}, { puznxqrbhbkt, &mggpajjlcjde}, {NULL, NULL} };
static const struct rkmkqkradcrt ceihxzdoikdk[] = { { puznxqrbhbkt, &eqitoovrxyqd}, { puznxqrbhbkt, &bpvijyotlmvf}, {NULL, NULL} };
static const struct rkmkqkradcrt chovbdoiwuhh[] = { { puznxqrbhbkt, &wnjibhmtfdhu}, {NULL, NULL} };
static const struct rkmkqkradcrt syivvqbzjvsn[] = { { lluxgncggttr, &eoaveuljorsc}, {NULL, NULL} };
static const struct rkmkqkradcrt kodnvjxczgca[] = { { puznxqrbhbkt, &sdfqwvcxeyas}, { puznxqrbhbkt, &ihkvuvwwmaoy}, {NULL, NULL} };
static const struct rkmkqkradcrt pjielnujmval[] = { { puznxqrbhbkt,	&jyucovsshrtm }, { puznxqrbhbkt,	&ftfdyiztnffs }, { puznxqrbhbkt,	&ihkvuvwwmaoy }, {NULL, NULL} };
static const struct rkmkqkradcrt ndxnkykbmyop[] = { { fvectlrkjgcy, &eoaveuljorsc}, {NULL, NULL} };
static const struct rkmkqkradcrt nboovnfjkgfx[] = { { puznxqrbhbkt, &wzzbshdvmfuy }, { puznxqrbhbkt, &vjstgznvwkvu}, {NULL, NULL} };
#ifndef _NO_DEPRECATED
static const struct rkmkqkradcrt kwjrkdphyxwx[] = { { sjbvlmyqyfqc, &ljhgmhnbrgdm}, {NULL, NULL} };
static const struct rkmkqkradcrt lvmiyfinpvbq[] = { { sjbvlmyqyfqc, &zcxjbkpetgso}, {NULL, NULL} };
#endif
static const struct rkmkqkradcrt fwblxfqxsysj[] = { { fvectlrkjgcy, &wzzbshdvmfuy}, { puznxqrbhbkt, &blljvzcyahvn}, { NULL, NULL} };
static const struct rkmkqkradcrt hfqueeoveodi[] = { { puznxqrbhbkt, &wfawmwqcuspd}, { puznxqrbhbkt, &vjstgznvwkvu}, {NULL, NULL} };
static const struct rkmkqkradcrt udiahqzowpry[] = { { puznxqrbhbkt, &rmibxbstxgsf}, { puznxqrbhbkt, &vazrfvrkbapt}, {NULL, NULL} };
static const struct rkmkqkradcrt nzdrvqfocyei[] = { { lluxgncggttr, &eoaveuljorsc}, { puznxqrbhbkt, &wfawmwqcuspd}, { puznxqrbhbkt, &vjstgznvwkvu}, {NULL, NULL} };
static const struct rkmkqkradcrt cqlqzezqqdqf[] = { { puznxqrbhbkt,	&jyucovsshrtm }, { puznxqrbhbkt,	&chfiflxfbslt }, { puznxqrbhbkt,	&lpwefxlnruwb }, { puznxqrbhbkt,	&ihkvuvwwmaoy }, {NULL, NULL} };
static const struct rkmkqkradcrt sqdyfxmptail[] = { { puznxqrbhbkt, &pvybvmlhuloz}, { fvectlrkjgcy, &wzzbshdvmfuy}, { puznxqrbhbkt, &ihkvuvwwmaoy}, { puznxqrbhbkt, &blljvzcyahvn}, {NULL, NULL} };
static const struct rkmkqkradcrt ftrneypforle[] = { { fvectlrkjgcy, &wzzbshdvmfuy}, {NULL, NULL} };
static const struct rkmkqkradcrt rxyfwfxpxesp[] = { { puznxqrbhbkt, &mumzefbliysr }, { puznxqrbhbkt, &ykjdmwnxjdyy }, {NULL, NULL} };
static const struct rkmkqkradcrt gizttlubtqim[] = { { lluxgncggttr, &bpxcimpdmgyd}, {NULL, NULL} };
static const struct rkmkqkradcrt lmywjygqgufm[] = { { puznxqrbhbkt,	&htbjievjghdk }, { puznxqrbhbkt,	&mumzefbliysr }, { puznxqrbhbkt,   &zmgjfsartzrg }, {NULL, NULL} };
static const struct rkmkqkradcrt kysxpyjrellz[] = { { puznxqrbhbkt, &nohalqadttgm}, {NULL, NULL} };
static const struct rkmkqkradcrt zjdweqorplwt[] = { { lluxgncggttr, &trzetqkqfqll}, { fvectlrkjgcy, &ekcbxtuytzpp}, {NULL, NULL} };
static const struct rkmkqkradcrt dmlyzcgbmdyq[] = { { puznxqrbhbkt, &lookktbgeqsm}, {NULL, NULL} };
static const struct rkmkqkradcrt zazglgqbjutv[] = { { fvectlrkjgcy, &ekcbxtuytzpp}, {NULL, NULL} };
static const struct rkmkqkradcrt xtabulhrwatt[] = { { puznxqrbhbkt,	&jogwgmcwqmjd }, { puznxqrbhbkt,	&ocifnmnhwcuz }, {NULL, NULL} };
static const struct rkmkqkradcrt ktebtmxrsqgx[] = { { puznxqrbhbkt,	&jyucovsshrtm }, { puznxqrbhbkt,	&yzemreiddrni }, {NULL, NULL} };
static const char* zcdepxnlhfam[] = { "M96b (XIAOMI/TCL)", "M100b (SHINCO/SAMSUNG/ELECTROLUX)", "T102b (WHIRLPOOL/BOSCH/AIRWELL)", "M128b (FUJITSU/McQUAY/TICA)", "M56b (TRUMA)" };
static const bc7215FormatPkt_t epnmnsekiecd[] = { {{.inByte=0x34}, {0x14, 0x1d, 0x10, 0xfd, 0x14, 0x1d, 0x09, 0xfd, 0x9c, 0x9c, 0x12, 0x0a, 0x77, 0x9d, 0x38, 0xf8, 0x00, 0x00, 0xfa, 0x7f, 0xb5, 0x1a, 0x97, 0x02, 0x48, 0x00, 0x3e, 0x01, 0x48, 0x00, 0xea, 0x00}}, {{.inByte=0x35}, {0x13, 0x9D, 0x24, 0xDD, 0x13, 0x7D, 0x69, 0x3D, 0x9D, 0x1D, 0x2E, 0xDB, 0xF2, 0x9B, 0xBD, 0xFE, 0x0F, 0x02, 0xCE, 0x5F, 0x81, 0x3A, 0xA3, 0x22, 0x74, 0x00, 0x75, 0x05, 0x73, 0x00, 0x26, 0x13}}, {{.inByte=0x21}, {0x10, 0xBD, 0x06, 0x5D, 0x06, 0x5D, 0x2B, 0x9D, 0x1F, 0x19, 0x35, 0x4D, 0x1A, 0xA7, 0x72, 0xF9, 0x00, 0x00, 0x22, 0x00, 0x44, 0x00, 0x66, 0x90, 0x0D, 0x00, 0x0A, 0x00, 0x48, 0x00, 0x39, 0x00}}, {{.inByte=0x36}, {0x1B, 0x1D, 0x17, 0xFD, 0x18, 0xBD, 0x0F, 0xBD, 0x9F, 0x1E, 0x5F, 0x83, 0x83, 0xC9, 0x2B, 0xFB, 0x84, 0x00, 0x84, 0x10, 0x06, 0x01, 0x90, 0x02, 0x2D, 0x00, 0xF5, 0x08, 0x13, 0x02, 0x2F, 0x03}}, {{.inByte=0x37}, {0x15, 0xDD, 0x0C, 0x7D, 0x0C, 0x3D, 0x04, 0xFD, 0x1F, 0x9F, 0x92, 0x88, 0x19, 0x22, 0xCB, 0xF8, 0x00, 0x80, 0x00, 0x10, 0xA9, 0x9A, 0x8B, 0x82, 0x37, 0xC3, 0x81, 0x8A, 0x21, 0xE7, 0x01, 0x20}} };
static const uint8_t hyjodwcqljqa[] = {0x60, 0x00, 0x9e, 0xc8, 0x00, 0x04, 0x52, 0x60, 0x00, 0x1c, 0x26, 0x10, 0x00, 0x4a};
static const uint8_t olmpfddqkkjy[] = {0x64, 0x00, 0x02, 0x05, 0x2C, 0x04, 0xD5, 0x56, 0x01, 0x6C, 0x50, 0xC4, 0x12, 0x40, 0x0C};
static const uint8_t ofjjmdznlfmm[] = {0x66, 0x00, 0x1C, 0x16, 0x00, 0x00, 0x87, 0x05, 0x80, 0x00, 0x21, 0xC1, 0x60, 0x00, 0x08};
static const uint8_t fdhbqixwwshg[] = {0x06, 0x01, 0x53, 0x04, 0x10, 0x04, 0x14, 0x10, 0x04, 0x00, 0x00, 0x04, 0x00, 0x04, 0x50, 0x10, 0x04, 0x14, 0x09, 0x00, 0x00, 0x00, 0x00, 0x50, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x50, 0x25};
static const uint8_t uxweqcryqymb[] = {0x38, 0x00, 0xE9, 0x0D, 0x10, 0x00, 0x00, 0x00, 0x06};
static const uint8_t bkphlagawpzn[] = {0x60, 0x00, 0x9e, 0xc8, 0x00, 0x04, 0x52, 0x60, 0x00, 0x8c, 0x26, 0x10, 0x00, 0xda};
static const uint8_t edqxuneuskwn[] = {0x64, 0x00, 0x02, 0x05, 0x2C, 0x04, 0xD5, 0x56, 0x01, 0x6C, 0x50, 0xD0, 0x12, 0x40, 0x0C};
static const uint8_t nwwdcuazidqk[] = {0x66, 0x00, 0x1C, 0x14, 0x00, 0x00, 0x87, 0x05, 0x00, 0x00, 0x21, 0xC1, 0x40, 0x00, 0x08};
static const uint8_t vmmouzzzegmr[] = {0x06, 0x01, 0x53, 0x04, 0x10, 0x04, 0x14, 0x10, 0x04, 0x00, 0x00, 0x04, 0x00, 0x04, 0x44, 0x10, 0x04, 0x10, 0x09, 0x00, 0x00, 0x00, 0x00, 0x50, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x50, 0x25};
static const uint8_t fdhptjjoaieq[] = {0x38, 0x00, 0xE9, 0x0D, 0x10, 0x00, 0x00, 0x00, 0x06};
static const bc7215DataVarPkt_t* wtytkqyaghkq[] = { (bc7215DataVarPkt_t*)bkphlagawpzn, (bc7215DataVarPkt_t*)edqxuneuskwn, (bc7215DataVarPkt_t*)nwwdcuazidqk, (bc7215DataVarPkt_t*)vmmouzzzegmr, (bc7215DataVarPkt_t*)fdhptjjoaieq };
static const bc7215DataVarPkt_t* vcsiwxyyfvux[] = { (bc7215DataVarPkt_t*)hyjodwcqljqa, (bc7215DataVarPkt_t*)olmpfddqkkjy, (bc7215DataVarPkt_t*)ofjjmdznlfmm, (bc7215DataVarPkt_t*)fdhbqixwwshg, (bc7215DataVarPkt_t*)uxweqcryqymb };
static const uint8_t jynelzyuxwhh = sizeof(wtytkqyaghkq)/sizeof(struct bc7215DataVarPkt_t*);
#ifndef _NO_DEPRECATED
static const uint8_t xptmjzvcndup[] = {0x23, 0xCB, 0x26};
static const uint8_t lxypqzemwbcv[] = {0x02, 0x20, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x06};
#endif
static const uint8_t jabkbczufziq[] = {0x28, 0x00, 0x68, 0xc2, 0x3d, 0x0f, 0x0f, 0x00, 0x00, 3, 1, 0xc0};
static const uint8_t kpymmlebxtex[] = {0x28, 0x00, 0x68, 0xc2, 0x3d, 0x0f, 0xf0, 0x28, 0x00, 0x68, 0xb2, 0x4d, 0x0f, 0xf0, 3, 1, 0xc0, 3, 1, 0xb0};
static const uint8_t pahapwkapoct[] = {0x48, 0x00, 0x1C, 0x28, 0x54, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x48, 0x00, 0x1C, 0x24, 0x49, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1a, 3, 1, 0x08, 3, 1, 0x04};
static const uint8_t cxohkmokmyfq[] = {0x60, 0x00, 0x6A, 0xF5, 0x79, 0x20, 0x00, 0x53, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x4E, 0x60, 0x00, 0x6A, 0xF5, 0x79, 0x20, 0x00, 0x93, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x52, 3, 5, 0x40, 3, 5, 0x80};
static const uint8_t dhksosdzslzz[] = {0x70, 0x00, 0x6A, 0x55, 0x79, 0x20, 0x00, 0x43, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x21, 0x00, 0x46, 0x70, 0x00, 0x6A, 0x55, 0x79, 0x20, 0x00, 0x83, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x21, 0x00, 0x4a, 3, 5, 0x40, 3, 5, 0x80};
static const uint8_t uyemfivwhxzx[] = {0x00, 0x00, 0x36, 0x1B, 0x5D, 0x12, 0x3D, 0x1B, 0x7D, 0x02, 0x9D, 0x1F, 0x9E, 0x21, 0x60, 0x06, 0x53, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x10, 0x30, 0x00, 0x21, 0x0F, 0xC6, 0x0F, 0x20, 0x0F, 0xC6, 0x0F, 0x3F, 0x50, 0x60, 0x00, 0x4d, 0xb2, 0xde, 0x21, 0x07, 0xf8, 0x4d, 0xb2, 0xde, 0x21, 0x07, 0xf8, 0x00, 0x00};
static const uint8_t ypimtguqicos[] = {0x00, 0x00, 0x36, 0x1A, 0x1D, 0x13, 0x1D, 0x1A, 0x1D, 0x01, 0x3D, 0x1F, 0x9E, 0x37, 0xB5, 0x07, 0x07, 0x4C, 0xFB, 0x00, 0x00, 0x38, 0x10, 0x38, 0x00, 0x94, 0xE2, 0x28, 0xA3, 0x9E, 0xEA, 0x3E, 0x87, 0x0D, 0x0A, 0x70, 0x00, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x22, 0xff, 0x01, 0xa0, 0x11, 0xc0, 0x00, 0x00 };
static const uint8_t prlsxzcwdtec[] = {0x00, 0x00, 0x36, 0x15, 0xBD, 0x12, 0xFD, 0x15, 0x5D, 0x03, 0x9D, 0x1F, 0x9E, 0x23, 0x61, 0x08, 0x4F, 0xAA, 0xF8, 0x00, 0x00, 0x90, 0x10, 0x90, 0x00, 0x4E, 0x0F, 0x39, 0x0F, 0x31, 0x0F, 0x36, 0x0F, 0xFF, 0x4D, 0x20, 0x01, 0x4F, 0xB0, 0x30, 0xCF, 0x90, 0x2E, 0x20, 0x80, 0x70, 0xAA, 0x10, 0xDA, 0x40, 0x84, 0xD6, 0x84, 0xAE, 0x36, 0x4F, 0xB0, 0x30, 0xCF, 0x90, 0x2E, 0x20, 0x80, 0x70, 0xAA, 0x10, 0xDA, 0x40, 0x84, 0xD6, 0x84, 0xAE, 0x36, 0x00, 0x00};
static const uint8_t bzijxlazacti[] = {0x00, 0x00, 0x36, 0x15, 0x9D, 0x12, 0xDD, 0x15, 0x9D, 0x02, 0x1D, 0x1F, 0x9E, 0x22, 0x63, 0x08, 0x51, 0xAA, 0xF8, 0x00, 0x00, 0x30, 0x10, 0x30, 0x00, 0x4C, 0x0F, 0x0F, 0x0F, 0x4C, 0x0F, 0xBE, 0x0F, 0xFF, 0x4D, 0x60, 0x00, 0x4D, 0xB2, 0xDE, 0x21, 0x07, 0xF8, 0x4D, 0xB2, 0xDE, 0x21, 0x07, 0xF8, 0x00, 0x00};
static const uint8_t xtlmgkrcqlnn[] = {0xB8, 0x00, 0x01, 0x10, 0x00, 0x40, 0xbf, 0xff, 0x00, 0xe6, 0x19, 0x89, 0x76, 0x01, 0xfe, 0x3f, 0xc0, 0x29, 0xd6, 0x16, 0xe9, 0x01, 0xfe, 0xa0, 0x5f, 0xb8, 0x00, 0x01, 0x10, 0x00, 0x40, 0xbf, 0xff, 0x00, 0xe6, 0x19, 0x89, 0x76, 0x01, 0xfe, 0x3f, 0xc0, 0x29, 0xd6, 0x16, 0xe9, 0x01, 0xfe, 0x90, 0x6f, 3, 21, 0x20};
static const uint8_t anqerytfgajq[] = {0x00, 0x00, 0x33, 0x1A, 0x1D, 0x13, 0x1D, 0x1A, 0x1D, 0x01, 0x3D, 0x1E, 0x9B, 0x19, 0x9F, 0x2A, 0xA8, 0x07, 0x31, 0x00, 0x80, 0x00, 0x10, 0x38, 0x20, 0x38, 0x10, 0x70, 0x20, 0x70, 0x10, 0x3E, 0x87, 0x30, 0x00, 0xa8, 0x00, 0x02, 0xb2, 0x0f, 0x00, 0x00, 0x00, 0xc0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0xff, 0x71, 0x80, 0x11, 0xc0, 0xa8, 0x00, 0x02, 0x92, 0x0f, 0x00, 0x00, 0x00, 0xf0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0xe2, 0xfe, 0x71, 0x80, 0x11, 0xf0, 3, 1, 0x20};
static const uint8_t ziamqdibacxe[] = {0x00, 0x00, 0x30, 0x1A, 0xDD, 0x13, 0xBD, 0x1A, 0x7D, 0x01, 0x9D, 0x1F, 0x98, 0x37, 0xB0, 0x07, 0x2B, 0xAA, 0xF8, 0x00, 0x00, 0x38, 0x10, 0x38, 0x00, 0x70, 0x10, 0x70, 0x00, 0x9E, 0x4A, 0x3E, 0x27, 0x39, 0x0D  , 0xa8, 0x00, 0x02, 0xb2, 0x0f, 0x00, 0x00, 0x00, 0xc0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0xff, 0x71, 0x80, 0x11, 0xc0, 0xa8, 0x00, 0x02, 0x92, 0x0f, 0x00, 0x00, 0x00, 0xf0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0xe2, 0xfe, 0x71, 0x80, 0x11, 0xf0, 3, 1, 0x20};
static const uint8_t mtryxubuibzp[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x80, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x09, 0x30, 0xa1, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0e};
static const uint8_t tevtnfjwtwtz[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x78, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfc, 0x08, 0x30, 0x91, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3e};
static const uint8_t fhqlwpmaqxor[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x90, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x0b, 0x41, 0x89, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x03, 0x20};
static const uint8_t siaayeanmves[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x08, 0x01, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x1a, 0x40, 0x89, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x10, 0x24, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0x00, 0xac};
static const uint8_t lcanhfiubhqa[] = {0x30, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0x78, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfc, 0x08, 0x30, 0x91, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3e};
static const uint8_t uwgsufqblxwz[] = {0x20, 0x00, 0x14, 0xeb, 0xc1, 0x3e, 0x40, 0x00, 0x14, 0xeb, 0x98, 0x91, 0x04, 0x00, 0x00, 0x00};
static const idfrrqsectwd goppveltigkj = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd wnpuxlawnbxv = {.set={0x14, 0x0f, 0x10, 0x24, 0x13, 0x24, NULL}};
static const idfrrqsectwd hfxdgbuatwke = {.set={0x14, 0x0f, 0x10, 0x24, 0x13, 0x24, djzhugjeizbo}};
static const idfrrqsectwd eogngwbanwxf = {.set={0x13, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd oqsswfmgihtp = {.set={0x10, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd mvzwwwhtgarp = {.set={0x10, 0x24, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd bzedzibrfgrd = {.set={0x14, 0x00, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd mdwgdukekmmi = {.set={0x92, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd jvwspbdlarsq = {.set={0x91, 0x2f, 0x10, 0x20, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd ugcqvtmqebkh = {.set={0x10, 0x0f, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd iblesequrknq = {.set={0x10, 0x00, 0x14, 0x00, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd wqsigdwrvhxv = {.set={0x10, 0x0f, 0x13, 0x0f, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd rjtdbpunizmw = {.set={0x10, 0x00, 0x13, 0x00, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd dgngnfdsytli = {.set={0x13, 0x0f, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd wtiilowhypxr = {.set={0x10, 0x00, 0x13, 0x0f, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd mnuuqppzetxe = {.set={0x13, 0x20, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd nqzynfrdqgyx = {.set={0x10, 0x0f, 0x14, 0x00, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd vuquyzbxithi = {.set={0x13, 0x0f, 0x13, 0x20, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd gnhrkilfvuvu = {.set={0x13, 0x0f, 0x14, 0x01, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd fyxhffgoainf = {.set={0x92, 0x0f, 0x13, 0x24, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd kmmjihktplmr = {.set={0x10, 0x00, 0x13, 0x00, 0x13, 0x20, NULL}};
static const idfrrqsectwd novrfvwupkjk = {.set={0x10, 0x00, 0x92, 0x02, 0x13, 0x20, NULL}};
static const idfrrqsectwd vuvobcgmcjoa= {.set={0x10, 0x0f, 0x92, 0x40, 0x92, 0x21, NULL}};
static const idfrrqsectwd ufexqpmknlvp = {.set={0x30, 0x2f, 0x31, 0x2f, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd smphvjjdfknu = {.set={0x72, 0x2f, 0x32, 0x24, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd dgassreliqom = {.set={0x72, 0x1f, 0x72, 0x2f, 0xf0, 0xf0, NULL}};
static const idfrrqsectwd ruxqriymumck = {.set={0x14, 0x0f, 0x10, 0x0f, 0xf0, 0xf0, bscleyzrxbqy}};
static const idfrrqsectwd snhhbawkkxag= {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, vqyzlkabxlpf}};
static const idfrrqsectwd dpwdtexgnhnq = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, vjkzzagamtio}};
static const idfrrqsectwd lrgklmoakmmz = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, ewatoudyzbqb}};
static const idfrrqsectwd zlzgpqkuxdqk = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, lilusymnjwcx}};
static const idfrrqsectwd aytekhetoumd = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, przomtqlpxra}};
static const idfrrqsectwd khxtegixwalv = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, prtwhhiucbev}};
static const idfrrqsectwd ktuxxlzspgpa = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, wtwvqloriidw}};
static const idfrrqsectwd sqjmgdqyrytx = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, vbyrtqvuowpi}};
static const idfrrqsectwd zbceoaavueaz = {.set={0x13, 0x0f, 0x13, 0x20, 0xf0, 0xf0, mwplgijsocxp}};
static const idfrrqsectwd lnbjpwimzvur = {.set={0x91, 0x2f, 0x91, 0x09, 0xf0, 0xf0, yrbkxjvxhmod}};
static const idfrrqsectwd xuspgpyovgdx = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, ndwodzulpeoi}};
static const idfrrqsectwd xafesltoxsdj = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, zxenslkplgnc}};
static const idfrrqsectwd ijhhcvhfkmzb = {.set={0x13, 0x20, 0xf0, 0xf0, 0xf0, 0xf0, jctlhxnxakbi}};
static const idfrrqsectwd slpynbuhdnel = {.set={0x10, 0x08, 0x13, 0x20, 0xf0, 0xf0, wsmfxcrfmdhb}};
#ifndef _NO_DEPRECATED
extern const struct icejugalibdt swacmtoygryi;
extern const struct icejugalibdt xswshvyipamb;
extern const struct icejugalibdt iwjmmuzzrjde;
extern const struct icejugalibdt dsbwwrznviti;
extern const struct icejugalibdt iibybupntnth;
extern const struct icejugalibdt cspimwcqitrf;
extern const struct icejugalibdt cbanstcjfvok;
extern const struct icejugalibdt xutuqlojlsvg;
static const idfrrqsectwd jhtkmadhgsys = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const lygcleobgeet*)&swacmtoygryi}};
static const idfrrqsectwd xgifxvxdemvf = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const lygcleobgeet*)&xswshvyipamb}};
static const idfrrqsectwd vguywtawfqau = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const lygcleobgeet*)&iwjmmuzzrjde}};
static const idfrrqsectwd lvkivpvrivlr = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const lygcleobgeet*)&dsbwwrznviti}};
static const idfrrqsectwd fuhksixhygsp = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const lygcleobgeet*)&iibybupntnth}};
static const idfrrqsectwd owkktceyoynf = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const lygcleobgeet*)&cspimwcqitrf}};
static const idfrrqsectwd lvoxlyzzgjvt = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const lygcleobgeet*)&cbanstcjfvok}};
static const idfrrqsectwd yyxvfdvqytvh = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const lygcleobgeet*)&xutuqlojlsvg}};
#endif
static const idfrrqsectwd oecemaclykon = {.nshlnwwdnxmh={82, 13, 0, 0}};
static const struct kdjigrgqrois qsdwmryagsdi = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 134, {35,32,35,32}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0, 0, 0x07, 0, klwpsnaremnn }, { 0x83, 2, 0x70, 4, ugfettxtzvmu }, { 0, 0, 0x30, 4, xwpraoqjyriq }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, buhbaxchubft, &tsubxikehlyo };
static const struct kdjigrgqrois vzovultgwxim = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 67, {35,32,0,0}, { 0, 1, 0x0f, 0, yesurpvnxprn}, { 0, 0, 0x07, 0, klwpsnaremnn}, { 0, 0, 0x30, 4, pxrplmlbjsmu}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, aqjqvbpvfzav, &tsubxikehlyo };
static const struct kdjigrgqrois ihtscewywgav = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, yesurpvnxprn}, { 0, 0, 0x07, 0, klwpsnaremnn}, { 0, 0, 0x30, 4, pxrplmlbjsmu}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois itojqesnivsv = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 216, {64,152,0,0}, { 1, 6, 0x1E, 1, yesurpvnxprn }, { 1, 5, 0x70, 4, fawtprpzhhee }, { 1, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bspdaeureyvl, &mpsippkzoqot };
static const struct kdjigrgqrois qkgefsfjihxs = { {0, 0, 0 , 0, 0, 0, 0}, 0x34, 43, {43,0,0,0}, { 0, 1, 0x0f, 0, yesurpvnxprn}, { 0, 0, 0x07, 0, klwpsnaremnn}, { 0, 0, 0x70, 4, khcvmumszyne}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 9}, 3, 0x70}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois otiqxygoiugu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, wcffplmknqjq}, { 0, 0, 0x07, 0, zkbwbzcqcsfl}, { 0, 0, 0x30, 4, uxfnphantyno}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois warcmtzmafxy = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, wcffplmknqjq}, { 0, 0, 0x07, 0, ybpyvlaaytbg}, { 0, 0, 0x30, 4, pxrplmlbjsmu}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois qdiclqzmfprt = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, yesurpvnxprn}, { 0, 0, 0x07, 0, ybpyvlaaytbg}, { 0, 0, 0x30, 4, pxrplmlbjsmu}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois rtqepxcnrkmf = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, yesurpvnxprn}, { 0, 0, 0x07, 0, ybpyvlaaytbg}, { 0, 0, 0x30, 4, uxfnphantyno}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois bitbbyjfaxnz = { {0, 1, 0, 0, 0, 1, 0}, 0x36, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, yesurpvnxprn}, { 0, 1, 0x07, 0, klwpsnaremnn}, { 0, 1, 0x30, 4, pxrplmlbjsmu}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, cuspzgwykqdl, NULL };
#ifndef _NO_DEPRECATED
const struct icejugalibdt xswshvyipamb = {NULL, &bitbbyjfaxnz, 1, 255};
#endif
static const struct kdjigrgqrois wtdggcarexgo = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 2, 0x0f, 0, yesurpvnxprn}, { 0, 1, 0x07, 0, klwpsnaremnn}, { 0, 1, 0x30, 4, pxrplmlbjsmu}, { 0x80, 0, 0, 0, NULL},
#ifndef _NO_DEPRECATED
&xgifxvxdemvf,
#else
&goppveltigkj,
#endif
{.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bbraenilafou, NULL };
static const struct kdjigrgqrois yfqozgtffslp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 1, 0xf8, 3, iavmeixdhscu}, { 0, 6, 0xe0, 5, osnwjoweeogm}, { 0, 4, 0xe0, 5, qawevoxbehgi}, { 0, 11, 0x07, 0, hrrwiswieqyp}, &ruxqriymumck, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 9, 0x20}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &sewqpovuqhmk };
static const struct kdjigrgqrois snmyfmqgljkf = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 1, 0xf8, 3, iavmeixdhscu}, { 0, 6, 0xe0, 5, osnwjoweeogm}, { 0, 4, 0xe0, 5, jyqazkeoaped}, { 0, 11, 0x07, 0, hrrwiswieqyp}, &ruxqriymumck, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 9, 0x20}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois obdhwlkevdnh = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 8, 0xff, 0, nsynuixoqddb}, { 0, 0, 0xf0, 4, aroekziciyls}, { 0, 9, 0x03, 0, pxrplmlbjsmu}, { 0, 0, 0x07, 0, mwqnxiyrlxlh}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois nptmjgcficvb = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 144, {72, 72, 0, 0}, { 0, 5, 0xf0, 4, wcffplmknqjq}, { 0, 6, 0x07, 0, dfwugjfgfggl}, { 0, 6, 0xC0, 6, pxrplmlbjsmu}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 6, 0x06}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, nxeyakvojjes, NULL };
static const struct kdjigrgqrois vxtwgewcbrtn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 1, 0x1f, 0, xgajasxpvaaj }, { 0, 4, 0x70, 4, fcuomdkkfykn }, { 0, 4, 0x03, 0, xxnpenfefvwy }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 5, 0xc0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, fqmqmhxzkuiy, &utjxvatgxgsc };
static const struct kdjigrgqrois jyftkapdkvor = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, tlvwpuqzrocu }, { 0, 6, 0x0f, 0, zsbjpadkqkhk }, { 0, 8, 0x07, 0, mbjbojreykno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &kjrvixocpywt };
static const struct kdjigrgqrois xzbvqmjcmrzm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, tlvwpuqzrocu }, { 0, 6, 0x0f, 0, zsbjpadkqkhk }, { 0, 8, 0x07, 0, mbjbojreykno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &lxeqpmwhdsih };
static const struct kdjigrgqrois fxvbogqptosy = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, itetzelofusv }, { 0, 6, 0x0f, 0, zsbjpadkqkhk }, { 0, 8, 0x07, 0, mbjbojreykno }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois ktckthnotann = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, tlvwpuqzrocu }, { 0, 6, 0x0f, 0, zsbjpadkqkhk }, { 0, 8, 0x07, 0, zrnrfxpyxqdn }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &lyouxofyxgly };
static const struct kdjigrgqrois dhszzjqldvoh = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, jkadkrgpzgra }, { 0, 6, 0x0f, 0, zsbjpadkqkhk }, { 0, 8, 0x07, 0, zrnrfxpyxqdn }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois rxxoilsyiquz = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, tlvwpuqzrocu}, { 0, 2, 0x07, 0, xxosrxtozcbu}, { 0, 0, 0xe0, 5, eyojthsxxrti}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois lgjgwbbusaqn = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, zkxewdgxxczo}, { 0, 2, 0x07, 0, nagzypxufjsh}, { 0, 0, 0xe0, 5, wnivcgizifji}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois hlthoqlvqnbw = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, zkxewdgxxczo}, { 0, 2, 0x07, 0, xxosrxtozcbu}, { 0, 0, 0xC0, 6, rigdugjowjha}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois comjchmqyjnc = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, zkxewdgxxczo}, { 0, 2, 0x07, 0, nagzypxufjsh}, { 0, 0, 0xC0, 6, rigdugjowjha}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois irtcvayuclqm = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, zkxewdgxxczo}, { 0, 2, 0x0f, 0, rkfhniaccipe}, { 0, 0, 0xff, 0, ixdyyzkferrh}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois solodyyhvfay = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, zkxewdgxxczo}, { 0, 2, 0x07, 0, nagzypxufjsh}, { 0, 0, 0xe0, 5, tzcwcehgndva}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois hsdqkoohntxk = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 4, 0x0f, 0, eljzwfefkbgl }, { 0, 4, 0x30, 4, eyqyhfzdrvxx }, { 0, 2, 0x07, 0, fbqfpruwxawg }, { 0, 0, 0, 0, NULL}, &wnpuxlawnbxv, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 8}, 2, 0xde}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 8}, 4, 0x07}}, regrxaxnulwm, &fgjdpnnbjdzl };
static const struct kdjigrgqrois rzctmzrxepqt = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 160, {56, 104, 0, 0}, { 1, 9, 0xFE, 1, bjwkqubxshep }, { 1, 5, 0x70, 4, lujrsilsbltr }, { 1, 10, 0x0f, 0, mscfzyeboixu }, { 0, 0, 0, 0, NULL}, &eogngwbanwxf, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bspdaeureyvl, NULL };
static const struct kdjigrgqrois oijxqsbsbgvq = { {0, 1, 0, 0 ,0, 0, 0}, 0x36, 216, {64, 152, 0, 0}, { 1, 6, 0xfe, 1, gcajfekxbndx }, { 1, 5, 0x70, 4, fawtprpzhhee}, { 1, 8, 0xf0, 4, mscfzyeboixu}, { 0, 0, 0, 0, NULL}, &eogngwbanwxf, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, wakpzpggevwl, &zycyzppwoguf };
static const struct kdjigrgqrois wmaugqnzazuz = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfe, 1, gcajfekxbndx }, { 3, 5, 0x70, 4, fawtprpzhhee }, { 3, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL }, &eogngwbanwxf, {.tfdvcvkctfsw.dntwwzvcqjni = {{3, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{3, 9}, 9, 0x0f}}, preizmuhmxgq, &pmwszizmljxs };
static const struct kdjigrgqrois ojzrnifzhdyk = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 128, {128, 0, 0, 0}, { 0, 0x83, 0xff, 0, nsynuixoqddb }, { 0, 1, 0x70, 4, klwpsnaremnn }, { 0, 2, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &oqsswfmgihtp, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x0f}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, vwyexfmkybys, NULL };
static const struct kdjigrgqrois jqeejpilbnit = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 128, {128, 0, 0, 0}, { 0, 0x83, 0xff, 0, nsynuixoqddb }, { 0, 1, 0x70, 4, klwpsnaremnn }, { 0, 2, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x0f}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, fqmqmhxzkuiy, NULL };
static const struct kdjigrgqrois zsfompibvyaa = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0x0f, 0, yesurpvnxprn }, { 0, 0, 0x70, 4, skxcssaagoud }, { 0, 1, 0x30, 4, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 1}, 0, 0x07}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois jvtsnrffmodk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0x0f, 0, abiypmrtzxpm }, { 0, 0, 0x70, 4, skxcssaagoud }, { 0, 1, 0x70, 4, pnsjkkzedchd }, { 0, 0, 0x0f, 0, nnalrticcmtl }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 1}, 0, 0x07}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois ywngqafzvspd = { {1, 1, 0, 0, 0, 0, 0}, 0x35, 80, {40, 40, 0, 0}, { 0, 0x1, 0xff, 0, nsynuixoqddb }, { 0x00, 0, 0x07, 0, jtaryvaqudln }, { 0, 0, 0x30, 6, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0,8},1,0x16}}, xbgrirfpgybc, NULL };
static const struct kdjigrgqrois vgofhluexhks = { {0, 1, 0, 0, 0, 0, 0}, 0x35, 80, {40, 40, 0, 0}, { 0, 0x1, 0xff, 0, nsynuixoqddb }, { 0x00, 0, 0x07, 0, jtaryvaqudln }, { 0, 0, 0x30, 6, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0,8},1,0x16}}, xbgrirfpgybc, NULL };
#ifndef _NO_DEPRECATED
const struct icejugalibdt iwjmmuzzrjde = {NULL, &ywngqafzvspd, 1, 165};
#endif
static const struct kdjigrgqrois ngunmbuoqatr = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0xff, 0, nsynuixoqddb }, { 0, 0, 0x07, 0, jtaryvaqudln }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0x80, 0, 0, 0, NULL },
#ifndef _NO_DEPRECATED
&vguywtawfqau,
#else
&goppveltigkj,
#endif
{.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0,8},1,0x16}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois abjcmxxyszoc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 0x1, 0x0f, 0, abiypmrtzxpm }, { 0, 2, 0x60, 5, klwpsnaremnn }, { 0, 3, 0xc0, 6, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois zfxrplzukyty = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 0x0, 0xff, 0, toplvrhwbvmk }, { 0, 4, 0xf0, 4, kxdkesgfinud }, { 0, 7, 0x0f, 0, msjhtfzlamsp }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, babjaboxqjtq, NULL };
static const struct kdjigrgqrois vvjoerjojqly = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 64, {32,32,0,0}, { 0, 2, 0x0f, 0, yesurpvnxprn }, { 0, 0, 0x0f, 0, zqnckmekinml }, { 0, 2, 0xf0, 4, chzhtjcvwqms }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, oevgixouztwt, NULL };
static const struct kdjigrgqrois emskvqsithcx = { {0, 1, 0, 0, 0, 1, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, abiypmrtzxpm }, { 0x00, 2, 0x07, 0, gbcpixqwpgdw }, { 0, 0, 0xf0, 4, gxnkayorkkno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, yrtrkmxqktlt, NULL };
static const struct kdjigrgqrois smtidvdtqwyk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 0x2, 0x0f, 0, yesurpvnxprn }, { 0x00, 10, 0x07, 0, cytfrmrvpryw }, { 0, 4, 0x70, 4, hytgptmhvrcd }, { 0, 12, 0x07, 0, dmhuhkdxtdkc }, &snhhbawkkxag, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 3, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, qdwpcydhuyly, NULL };
static const struct kdjigrgqrois lagigftxqlnq = { {1, 0, 1, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 4, 0xf0, 4, oibwwdmldgns }, { 0x00, 4, 0x0c, 2, kvhxtlfrqrhg }, { 0x80, 2, 0xe0, 5, zwxjxwbjkkqb }, { 2, 1, 0xff, 0, ibdfuvhhbxip }, &hfxdgbuatwke, {.npikivgkyypz = (const bc7215DataVarPkt_t*)uyemfivwhxzx}, tayqfyoxkksz, &rtbpdhogkzei };
static const struct kdjigrgqrois wlpvcoydygxy = { {1, 0, 1, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 4, 0xf0, 4, oibwwdmldgns }, { 0x00, 4, 0x0c, 2, kvhxtlfrqrhg }, { 0x80, 2, 0xe0, 5, dgndpjpipgeb }, { 2, 1, 0xff, 0, fhhpwxvyklnn }, &hfxdgbuatwke, {.npikivgkyypz = (const bc7215DataVarPkt_t*)uyemfivwhxzx}, tayqfyoxkksz, NULL };
static const struct kdjigrgqrois vjiakqzshpyz = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xf0, 4, cgvksurxswjr }, { 0x00, 1, 0x70, 4, klwpsnaremnn }, { 0x40, 3, 0xf0, 4, msjhtfzlamsp }, { 0, 3, 0x0f, 0, xzabpopfxpzr }, &ufexqpmknlvp, {.npikivgkyypz = (bc7215DataVarPkt_t*)jabkbczufziq}, smrjemyxbsko, NULL };
static const struct kdjigrgqrois vqwkeghjpzim = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0x80, 0, 0x0f, 0, aqleomuwmxuh }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 4, 0x40, 6, lngoeqphvnen }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois rlpdfbqgfyqf = { {0, 1, 0, 0, 0, 0, 0}, 0x3e, 129, {64, 65, 0, 0}, { 0, 2, 0x1e, 1, yesurpvnxprn }, { 0x0, 1, 0x07, 0, rhgrgpfgjtpx }, { 0, 1, 0x70, 4, ioimiaznntiw }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x30}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 5, 0xc0}}, bqkgazqwpcci, NULL };
static const struct kdjigrgqrois mobbnelvcdbm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0x0, 0, 0x70, 4, ybpyvlaaytbg }, { 0, 1, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0x07, 0, puyaxzxepvdq }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois rndgwlqalsuw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0x0, 0, 0x70, 4, lilljgxuegds }, { 0, 1, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 1}, 0, 0x0f}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois zusrguarcnzw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 80, {80, 0, 0, 0}, { 0, 1, 0x0f, 0, abiypmrtzxpm }, { 0x0, 0, 0x70, 4, ybpyvlaaytbg }, { 0, 1, 0x30, 4, uxfnphantyno }, { 0, 0, 0x07, 0, puyaxzxepvdq }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois zaxpayyxrtag = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0x0, 0, 0x70, 4, lilljgxuegds }, { 0, 1, 0x30, 4, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 1}, 0, 0x0f}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois ysbgyajixyxd = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0x0, 0, 0x70, 4, ybpyvlaaytbg }, { 0, 1, 0x30, 4, uxfnphantyno }, { 0, 0, 0x0f, 0, hjnvmznearzt }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois addaktyujmok = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 112, {16, 40, 16, 40}, { 1, 3, 0xf0, 4, yesurpvnxprn }, { 0x81, 0, 0xc0, 6, kbmodlblaucy }, { 1, 1, 0x30, 4, uxfnphantyno }, { 0, 0, 0xc0, 6, gwtcevjpkynw }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0xc0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 9}, 0, 0xc0}}, sqdyfxmptail, NULL };
static const struct kdjigrgqrois nwxvuxlmrgyt = { {0, 0, 1, 0, 0, 0, 0}, 0x37, 40, {40, 0, 0, 0}, { 0x40, 3, 0xf0, 4, yesurpvnxprn }, { 0x0, 1, 0x70, 4, klwpsnaremnn }, { 0, 3, 0xf0, 4, msjhtfzlamsp }, { 0, 3, 0x0f, 0, cxeasujrjham }, &smphvjjdfknu, {.npikivgkyypz = (bc7215DataVarPkt_t*)kpymmlebxtex}, smrjemyxbsko, NULL };
static const struct kdjigrgqrois aprwhnxdzuoc = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0x0f, 0, iomplekazizk }, { 0x0, 3, 0x70, 4, dfwugjfgfggl }, { 0, 2, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &rjtdbpunizmw, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois mlwbkjywxiab = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 7, 0xe0, 5, osnwjoweeogm }, { 0, 5, 0xe0, 5, qawevoxbehgi }, { 0, 12, 0x07, 0, hrrwiswieqyp }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &pesaoochqbkt };
static const struct kdjigrgqrois xnlwucyxdqnq = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 160, {112, 48, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 7, 0xe0, 5, osnwjoweeogm }, { 0, 5, 0xe0, 5, qawevoxbehgi }, { 0, 12, 0x07, 0, hrrwiswieqyp }, &dpwdtexgnhnq, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 9}, 10, 0x10}}, wakpzpggevwl, NULL };
static const struct kdjigrgqrois salvsmnnupvn = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 160, {112, 48, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 7, 0xe0, 5, osnwjoweeogm }, { 0, 5, 0xe0, 5, qawevoxbehgi }, { 0, 12, 0x07, 0, hrrwiswieqyp }, &lrgklmoakmmz, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 9}, 10, 0x10}}, wakpzpggevwl, NULL };
static const struct kdjigrgqrois lwmfcjddzyro = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 0x1, 0xf0, 4, yesurpvnxprn }, { 0x0, 6, 0xf0, 4, esmhlrvmdxsn }, { 0, 5, 0xc0, 6, uxfnphantyno }, { 0, 1, 0x07, 0, cvnwzckfulgx }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &wsgdrhxlewqi };
static const struct kdjigrgqrois ufxcvttqyigs = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 136, {112, 24, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 7, 0xe0, 5, osnwjoweeogm }, { 0, 5, 0xe0, 5, qawevoxbehgi }, { 0, 12, 0x07, 0, hrrwiswieqyp }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0xc0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois hrocdvrwuugo = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 88, {88, 0, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 6, 0xe0, 5, pksciaxzldqs }, { 0, 5, 0xe0, 5, hgmmvxysuqkh }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois yippqohmxqux = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 88, {88, 0, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 6, 0xe0, 5, pksciaxzldqs }, { 0, 4, 0xe0, 5, qawevoxbehgi }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ydbrzideejmo, NULL };
static const struct kdjigrgqrois eohspvxcikix = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, yesurpvnxprn }, { 0x0, 5, 0x70, 4, szfgznqnnsmy }, { 0, 4, 0x07, 0, icgmlvzoyhwj }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 9}, 0, 0x02}}, ybnpeclipoez, NULL };
static const struct kdjigrgqrois sbkqrklncffc = { {1, 1, 0, 0, 0, 0 ,0}, 0x37, 64, {16, 48, 0, 0}, { 1, 3, 0xf0, 4, yesurpvnxprn }, { 1, 5, 0xe0, 5, bwhuawgvrvdd }, { 1, 1, 0x30, 4, ruqjijcpnpfa }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ftrneypforle, NULL };
static const struct kdjigrgqrois evnhdkvockig = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 4, 0xFF, 0, qqlbxsshbipj }, { 0, 5, 0xe0, 5, qawevoxbehgi }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0xc0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 8}, 12, 5}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois grkmijryilwt = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 7, 0xe0, 5, osnwjoweeogm }, { 0, 5, 0xe0, 5, qawevoxbehgi }, { 0, 12, 0x0f, 0, tfowxtaoekye }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 4, 0x2f}}, ioevhtzcnyea, NULL };
static const struct kdjigrgqrois vxzprvcbybmv = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 7, 0xe0, 5, osnwjoweeogm }, { 0, 5, 0xe0, 5, qawevoxbehgi }, { 0, 12, 0x0f, 0, tfowxtaoekye }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0xf0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 4, 6}}, oylrrdvgjqxg, NULL };
static const struct kdjigrgqrois cloexghowbkj = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, yesurpvnxprn }, { 0x0, 2, 0x70, 4, lrpdggnbestj }, { 0, 1, 0x30, 4, rigdugjowjha }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, abjpqmkybtzk, NULL };
static const struct kdjigrgqrois ufeyduqeesnu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 136, {136, 0, 0, 0}, { 0, 0x46, 0xFF, 0, ecnfemzkobsa }, { 0x0, 5, 0xf0, 4, vtxztbnmjowx }, { 0, 5, 0x0f, 0, qdhcshkfupkm }, { 0, 0, 0, 0, NULL }, &mvzwwwhtgarp, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 8, 0x20}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0}, 0, 0}}, vwseaoclbrqg, NULL };
static const struct kdjigrgqrois yzifbmmicbjn = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, abiypmrtzxpm }, { 0, 1, 0x07, 0, rhhlairhixpb }, { 0, 2, 0x07, 0, btjmcnhdbjhv }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0xc0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0}, 0, 0}}, wrarviifhafn, &ogxrkxpsvrkj };
static const struct kdjigrgqrois jyhyyaytglkf = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, tlvwpuqzrocu }, { 0x0, 8, 0xe0, 5, nagzypxufjsh }, { 0, 6, 0x60, 5, rigdugjowjha }, { 0, 4, 0x07, 0, puvfsaegothg }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 6, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 4, 0x07}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois zmwhyiyarosl = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, tlvwpuqzrocu }, { 0x0, 8, 0xe0, 5, nagzypxufjsh }, { 0, 6, 0x60, 5, rigdugjowjha }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 6, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 4, 0x07}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois yhlkknfrvswq = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, tlvwpuqzrocu }, { 0x0, 4, 0x07, 0, xgrgvuukfmxw }, { 0, 6, 0x60, 5, rigdugjowjha }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 6, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 4, 0x07}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois lbdmjbcijpyv = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, tlvwpuqzrocu }, { 0x0, 8, 0xe0, 5, nagzypxufjsh }, { 0, 6, 0xe0, 5, wnivcgizifji }, { 0, 4, 0x07, 0, puvfsaegothg }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 6, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 4, 0x07}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois dsfnontaqxot = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, qsjskffkkdso }, { 1, 1, 0x07, 0, gisktbnifqko }, { 1, 0, 0x03, 0, uxfnphantyno }, { 2, 1, 0xff, 0, aghhidcycdjo }, &zlzgpqkuxdqk, {.tfdvcvkctfsw.dntwwzvcqjni = {{2, 9}, 4, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, pqgspokxpjpv, &kaduikdcfhdi };
static const struct kdjigrgqrois hbdqlqwxryuw = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 112, {16, 96, 0, 0}, { 1, 1, 0xf0, 4, qsjskffkkdso }, { 1, 1, 0x07, 0, gisktbnifqko }, { 1, 0, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 3}, 0, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wtzqzrgdbyvn, NULL };
static const struct kdjigrgqrois nsljayaudxbv = { {0, 1, 0, 0 ,0, 0 ,0}, 0x34, 184, {24, 160, 0, 0}, { 1, 3, 0xff, 0, isxphlemnplx }, { 1, 0, 0x3f, 0, hrtkqdhjbsji }, { 1, 1, 0xff, 0, duufbnoqquua }, { 1, 16, 0xff, 0, yrnzpkzxrloi }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wtzqzrgdbyvn, NULL };
static const struct kdjigrgqrois aiodepttskzw = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 3, 0xf0, 4, qsjskffkkdso }, { 0, 3, 0x07, 0, gisktbnifqko }, { 0, 2, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, &wsgdrhxlewqi };
static const struct kdjigrgqrois ubyfsginzvsk = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 3, 0xf0, 4, yesurpvnxprn }, { 0, 3, 0x07, 0, gisktbnifqko }, { 0, 2, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct aaqxyrxbybvu onbudwwrfwnd = { .shzveqsbwpgu = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 168, {24, 144, 0, 0}, { 1, 12, 0xfe, 1, zyjffvcebxgi }, { 1, 14, 0x0f, 0, jamvdqsxoxbt }, { 1, 14, 0xf0, 4, acudvgmiohqz }, { 1, 8, 0x0f, 0, yrlvcfroqdpn }, &goppveltigkj, {.gvgpztzhmfxl = nvptsvwjxykb}, tmpyrvtulwjk, &zmohcgknxaxm }, .yfesjtznxtiz = jamvdqsxoxbt };
static const struct kdjigrgqrois vjeofgozldyf = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 136, {24, 112, 0, 0}, { 0x41, 12, 0xfe, 1, zyjffvcebxgi }, { 0x61, 12, 0x0f, 0, (const uint8_t*)&onbudwwrfwnd }, { 1, 12, 0xf0, 4, acudvgmiohqz }, { 1, 8, 0x0f, 0, yrlvcfroqdpn }, &dgassreliqom, {.npikivgkyypz = (bc7215DataVarPkt_t*)xtlmgkrcqlnn}, tmpyrvtulwjk, &zmohcgknxaxm };
static const struct kdjigrgqrois gwswllrtoojq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, xgajasxpvaaj }, { 0, 4, 0x30, 4, pnkrgohcdztf }, { 0, 4, 0x03, 0, xxnpenfefvwy }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 5, 0x40}}, fqmqmhxzkuiy, &wsgdrhxlewqi };
static const struct kdjigrgqrois hzfvrhtypamp = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0xf0, 4, qsjskffkkdso }, { 0, 3, 0x07, 0, gisktbnifqko }, { 0, 2, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois pnnsprfpmekw = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0xf0, 4, qsjskffkkdso }, { 0, 3, 0x07, 0, gisktbnifqko }, { 0, 2, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &trqvcxreynbl };
static const struct kdjigrgqrois gbbgksgdnkdf = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, xgajasxpvaaj }, { 0x80, 4, 0x30, 4, pnkrgohcdztf }, { 0, 4, 0x03, 0, xxnpenfefvwy }, { 0, 2, 0xff, 0, mtiuktpixtdc }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 5, 0x40}}, fqmqmhxzkuiy, NULL };
static const struct kdjigrgqrois nowzwkhiingd = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0x0, 0, 0x70, 4, ybpyvlaaytbg }, { 0, 1, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0x0f, 0, hjnvmznearzt }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois ysxdfmkzzeff = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, qsjskffkkdso }, { 0x0, 0, 0x70, 4, ybpyvlaaytbg }, { 0, 1, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0x0f, 0, hjnvmznearzt }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois jzdrmsqtjjop = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0x1f, 0, xgajasxpvaaj }, { 0x80, 4, 0x30, 4, indxgieqtgxq }, { 0, 4, 0x03, 0, xxnpenfefvwy }, { 0, 2, 0x10, 4, qrxmfvknnijn }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3},5, 0x04}}, babjaboxqjtq, &fgjdpnnbjdzl };
static const struct kdjigrgqrois tgltsveuxqxt = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, xgajasxpvaaj }, { 0x80, 4, 0x30, 4, pnkrgohcdztf }, { 0, 4, 0x0c, 2, xxnpenfefvwy }, { 0, 2, 0xff, 0, krzvsrfegkai }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 5, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 9}, 5, 0x80}}, fqmqmhxzkuiy, NULL };
static const struct kdjigrgqrois dfajapsbcutk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0x1f, 0, xgajasxpvaaj }, { 0x80, 4, 0x30, 4, pnkrgohcdztf }, { 0, 4, 0x03, 0, xxnpenfefvwy }, { 0, 2, 0x10, 4, qrxmfvknnijn }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 9}, 1, 0x02}}, babjaboxqjtq, NULL };
static const struct kdjigrgqrois sguwdmkcrbbv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, tlvwpuqzrocu }, { 0, 6, 0x0f, 0, zsbjpadkqkhk }, { 0, 8, 0x07, 0, mbjbojreykno }, { 0, 12, 0xff, 0, jaripcivdrkj}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &bmoqnftmravx };
static const struct kdjigrgqrois nocxnnmyrydy = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 113, {113, 0, 0, 0}, { 0, 7, 0x0f, 0, tlvwpuqzrocu}, { 0, 6, 0x0f, 0, zsbjpadkqkhk}, { 0, 8, 0x07, 0, mbjbojreykno}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, isrkkhepioxo, NULL };
static const struct kdjigrgqrois bxpwzfhptljc = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 168, {56, 56, 56, 0}, { 0, 5, 0x0f, 0, yesurpvnxprn }, { 0, 5, 0xf0, 4, kcjvjfzxugrm }, { 0, 3, 0x03, 0, pxrplmlbjsmu }, { 0, 5, 0x20, 5, aoagqbdascbj }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, swahqnbgddbn, NULL };
static const struct kdjigrgqrois qvcgxekxpsdm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, tlvwpuqzrocu }, { 0x80, 6, 0x0f, 0, zsbjpadkqkhk }, { 0, 8, 0x07, 0, mbjbojreykno }, { 0, 8, 0xf8, 0, sentaqwqpmtd }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois vkpemgbncqjj = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 168, {56, 56, 56, 0}, { 0, 5, 0x0f, 0, yesurpvnxprn }, { 0, 5, 0xf0, 4, nzktiygcyrql }, { 0, 3, 0x03, 0, uxfnphantyno }, { 0, 5, 0x20, 5, aoagqbdascbj }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, swahqnbgddbn, NULL };
static const struct kdjigrgqrois kguzzbuvgism = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0xff, 0, flqyofepsvvg }, { 0, 0, 0x07, 0, ybpyvlaaytbg }, { 0, 2, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois nbxxqqaadchu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x0f, 0, abiypmrtzxpm }, { 0, 0, 0x07, 0, ybpyvlaaytbg }, { 0, 2, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois jitbaxkawwpp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0, 0, 0x70, 4, ybpyvlaaytbg }, { 0, 1, 0x30, 4, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 1}, 0, 0x87}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois hltxijiaeuhg = { {1, 0, 0, 1, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 7, 0x1e, 1, yesurpvnxprn }, { 0, 5, 0x07, 0, klwpsnaremnn }, { 0, 6, 0xff, 0, clmudmnzybys }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, qdwpcydhuyly, NULL };
static const struct kdjigrgqrois diiyajjbgcsr = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 224, {112, 112, 0, 0}, { 1, 7, 0x0f, 0, tlvwpuqzrocu }, { 1, 6, 0x0f, 0, zsbjpadkqkhk }, { 0x81, 8, 0x07, 0, mbjbojreykno }, { 0, 6, 0xe0, 5, xofnhcyesrof }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1,9},5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0}, 0, 0}}, gtjjaygnutej, &ikpnyldpmuuy };
static const struct kdjigrgqrois kxnwuxwabopj = { {1, 1, 0, 0, 0, 0, 0}, 0x35, 88, {44, 44, 0, 0}, { 0, 0x1, 0xff, 0, nsynuixoqddb }, { 0x00, 0, 0x07, 0, jtaryvaqudln }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, xbgrirfpgybc, NULL };
#ifndef _NO_DEPRECATED
const struct icejugalibdt dsbwwrznviti = {NULL, &kxnwuxwabopj, 1, 165};
#endif
static const struct kdjigrgqrois pamgcdjugiwi = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 0x1, 0xff, 0, nsynuixoqddb }, { 0x00, 0, 0x07, 0, jtaryvaqudln }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0x80, 0, 0, 0, NULL },
#ifndef _NO_DEPRECATED
&lvkivpvrivlr,
#else
&goppveltigkj,
#endif
{.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois xmyrzlaktydf = { {1, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0xf0, 4, xyulyfqvekqy }, { 0x00, 1, 0x0c, 2, kowbieqwlbpm }, { 0, 1, 0x03, 0, uhtggzmnvqwz }, { 0, 2, 0xf0, 4, hvkesnuxkauc }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,9},0,0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, ozuzhfdydbgr, NULL };
static const struct kdjigrgqrois blhbhbjngidd = { {1, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0xf0, 4, zkxewdgxxczo }, { 0x00, 1, 0x0c, 2, kowbieqwlbpm }, { 0, 1, 0x03, 0, uhtggzmnvqwz }, { 0, 2, 0xf0, 4, coadwkqmwcoz }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,9},0,0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ozuzhfdydbgr, NULL };
static const struct kdjigrgqrois gdlxkzwqlgjm = { {1, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0xf0, 4, zkxewdgxxczo }, { 0x00, 1, 0x0c, 2, kowbieqwlbpm }, { 0, 1, 0x03, 0, uhtggzmnvqwz }, { 0, 2, 0xf0, 4, hvkesnuxkauc }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,9},0,0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ozuzhfdydbgr, NULL };
static const struct kdjigrgqrois sswomsklwbzb = { {1, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0xf0, 4, wcffplmknqjq }, { 0x00, 1, 0x0c, 2, kowbieqwlbpm }, { 0, 1, 0x03, 0, uhtggzmnvqwz }, { 0, 2, 0xf0, 4, coadwkqmwcoz }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,9},0,0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ozuzhfdydbgr, NULL };
static const struct kdjigrgqrois lswvpguisezg = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 288, {144, 144, 0, 0}, { 0, 7, 0x0f, 0, yesurpvnxprn }, { 0x80, 6, 0x38, 3, jhpavfqdtmow }, { 0, 9, 0x07, 0, khcvmumszyne }, { 0, 8, 0x07, 0, ivwochzhifej }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x20}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, yozquwuvvduy, &fihultrelcxx };
static const struct kdjigrgqrois qvibprkepsky = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 144, {144, 0, 0, 0}, { 0, 7, 0x0f, 0, yesurpvnxprn }, { 0x80, 6, 0x38, 3, jhpavfqdtmow }, { 0, 9, 0x07, 0, khcvmumszyne }, { 0, 8, 0x07, 0, ivwochzhifej }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x20}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois ebejwdgxdagz = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 184, {40, 144, 0, 0}, { 1, 7, 0x0f, 0, tlvwpuqzrocu }, { 0x1, 6, 0x07, 0, jhpavfqdtmow }, { 1, 8, 0x07, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, bspdaeureyvl, NULL };
static const struct kdjigrgqrois zcswrvhcligz = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 184, {40, 144, 0, 0}, { 1, 7, 0x0f, 0, yesurpvnxprn }, { 0x81, 6, 0x38, 3, zsbjpadkqkhk }, { 1, 9, 0x03, 0, pxrplmlbjsmu }, { 1, 8, 0x07, 0, ivwochzhifej }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x20}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, bspdaeureyvl, &gcfiyuhrkzvo };
static const struct kdjigrgqrois pktuqtwsehkd = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 88, {24, 64, 0, 0}, { 1, 6, 0xf0, 4, smjxfwmclffb }, { 1, 6, 0x07, 0, nagzypxufjsh }, { 1, 4, 0xe0, 5, ywtxvccdnvhm }, { 0, 0, 0, 0, NULL }, &iblesequrknq, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 3}, 2, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{1,3},6,0x08}}, tmpyrvtulwjk, NULL };
static const struct kdjigrgqrois stitjlhumoje = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 136, {40, 48, 48, 0}, { 1, 1, 0xf0, 4, yesurpvnxprn }, { 1, 1, 0x07, 0, lmnidopusvcf }, { 1, 2, 0x06, 1, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, vbmxdzxbjosn, &ddkuvswepyou };
static const struct kdjigrgqrois nwlnayjhawnw = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 136, {40, 48, 48, 0}, { 1, 0, 0x1e, 1, yesurpvnxprn }, { 1, 1, 0x07, 0, lmnidopusvcf }, { 1, 2, 0x06, 1, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, vbmxdzxbjosn, &rhzkmpegvlsw };
static const struct kdjigrgqrois rjtzzvpmwdkl = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 102, {51, 51, 0, 0}, { 0, 2, 0xf0, 4, tlvwpuqzrocu }, { 0, 1, 0x0f, 0, zsbjpadkqkhk }, { 0, 2, 0x07, 0, ugfettxtzvmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x03}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, xbgrirfpgybc, &geexgwgzyaii };
static const struct kdjigrgqrois auyikmaqkcxc = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 2, 0xf0, 4, zkxewdgxxczo }, { 0x0, 2, 0x07, 0, xxosrxtozcbu }, { 0, 0, 0x70, 4, rxvuabhfspsf }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois bjlumvyqzbno = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 6, 0xf0, 4, xyulyfqvekqy }, { 1, 6, 0x07, 0, nagzypxufjsh }, { 1, 4, 0xe0, 5, ywtxvccdnvhm }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 3}, 6, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, tmpyrvtulwjk, NULL };
static const struct kdjigrgqrois bgbjyjjqivrh = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 6, 0xf0, 4, zkxewdgxxczo }, { 1, 6, 0x07, 0, nagzypxufjsh }, { 1, 4, 0xe0, 5, ywtxvccdnvhm }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 3}, 6, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, tmpyrvtulwjk, NULL };
static const struct kdjigrgqrois egydrbpwupnm = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 120, {24, 96, 0, 0}, { 1, 2, 0xf0, 4, zkxewdgxxczo }, { 1, 2, 0x07, 0, nagzypxufjsh }, { 1, 8, 0x18, 3, uhtggzmnvqwz }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, tmpyrvtulwjk, NULL };
static const struct kdjigrgqrois xdpfxlhmecnq = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 120, {24, 96, 0, 0}, { 1, 2, 0xf0, 4, zkxewdgxxczo }, { 1, 2, 0x07, 0, nagzypxufjsh }, { 1, 8, 0x18, 3, uhtggzmnvqwz }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, tmpyrvtulwjk, NULL };
static const struct kdjigrgqrois yjjtbxlfhcdl = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 86, {43, 43, 0, 0}, { 0, 2, 0xf0, 4, tlvwpuqzrocu }, { 0x80, 0, 0x0c, 2, isjaoyqxvcxy }, { 0, 0, 0x30, 4, uxfnphantyno }, { 0, 4, 0x20, 5, ntivtupwshew }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, xbgrirfpgybc, NULL };
static const struct kdjigrgqrois qvwhqkmkxnvf = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 84, {24, 56, 4, 0}, { 1, 1, 0xf0, 4, tlvwpuqzrocu }, { 1, 0, 0xe0, 5, rydzwodolknx }, { 1, 2, 0x70, 4, mbjbojreykno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, ifbevdpuzizy, NULL };
static const struct kdjigrgqrois ryrxvjdrnlim = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {24, 64, 0, 0}, { 1, 6, 0xf0, 4, zkxewdgxxczo }, { 1, 6, 0x07, 0, nagzypxufjsh }, { 1, 4, 0xe0, 5, ywtxvccdnvhm }, { 0, 0, 0, 0, NULL }, &bzedzibrfgrd, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 3}, 6, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, tmpyrvtulwjk, NULL };
static const struct kdjigrgqrois klaivszdgmir = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 4, 0xf0, 4, zkxewdgxxczo }, { 0x0, 4, 0x07, 0, nagzypxufjsh }, { 0, 2, 0x70, 4, mefowlgychxe }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0,3},4,0x08}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois jorkahsqbkmq = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 152, {24, 128, 0, 0}, { 1, 4, 0x0f, 0, zkxewdgxxczo }, { 1, 2, 0x07, 0, nagzypxufjsh }, { 1, 6, 0x07, 0, yfohupfsvwbj }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, tmpyrvtulwjk, NULL };
static const struct kdjigrgqrois tgsbcjgjkrvf = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 128, {128, 0, 0, 0}, { 0, 6, 0x3e, 1, xgajasxpvaaj }, { 0, 5, 0xc0, 6, cytfrmrvpryw }, { 0, 5, 0x0c, 2, xxnpenfefvwy }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, liluzfedrafi, NULL };
static const struct kdjigrgqrois acxcrwvuzqtc = { {0, 1, 0, 0 ,0, 0, 0}, 0x31, 96, {32, 32, 32, 0}, { 0, 0, 0x0f, 0, abiypmrtzxpm }, { 0, 2, 0x07, 0, gbcpixqwpgdw }, { 0, 0, 0x70, 4, gxnkayorkkno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, nuszhkpvkapz, NULL };
static const struct kdjigrgqrois bapsveqsvjdi = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {56, 120, 0, 0}, { 1, 10, 0x3e, 1, fsfcmbkqsvit }, { 1, 7, 0x70, 4, ttywxwiboswj }, { 1, 11, 0x70, 4, ugfettxtzvmu }, { 1, 6, 0x04, 2, tsrnfzhmsuef }, &aytekhetoumd, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 7, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, wakpzpggevwl, NULL };
static const struct kdjigrgqrois nhnzfpcujops = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 6, 0x3e, 1, xgajasxpvaaj }, { 0, 5, 0xe0, 5, zuyjppaxffro }, { 0, 5, 0x0e, 1, blflvskhozvo }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, cxtrtpjnxbgx, &mpsippkzoqot };
static const struct kdjigrgqrois ezggtzgiuaco = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 56, {12, 44, 0, 0}, { 1, 3, 0x0f, 0, yesurpvnxprn }, { 1, 4, 0x07, 0, klwpsnaremnn }, { 1, 3, 0xe0, 5, gljwqnkgvonk }, { 0, 0, 0, 0, NULL }, &mvzwwwhtgarp, {.npikivgkyypz = (bc7215DataVarPkt_t*)ypimtguqicos}, uviddcgaqelg, &nhlnkdhhbpnm };
static const struct kdjigrgqrois ovmapinlwdgb = { {0, 1, 1, 0, 0, 0, 0}, 0x31, 112, {12, 44, 12, 44}, { 3, 3, 0x0f, 0, yesurpvnxprn }, { 3, 4, 0x07, 0, klwpsnaremnn }, { 3, 3, 0xe0, 5, gljwqnkgvonk }, { 0, 0, 0, 0, NULL }, &mvzwwwhtgarp, {.npikivgkyypz = (bc7215DataVarPkt_t*)anqerytfgajq}, sypsknquhmzz, &ssbdydnaatik };
static const struct kdjigrgqrois vfwjxjeylucs = { {0, 1, 1, 0, 0, 0, 0}, 0x36, 112, {12, 44, 12, 44}, { 3, 3, 0x0f, 0, yesurpvnxprn }, { 3, 4, 0x07, 0, klwpsnaremnn }, { 3, 3, 0xe0, 5, gljwqnkgvonk }, { 0, 0, 0, 0, NULL }, &mvzwwwhtgarp, {.npikivgkyypz = (bc7215DataVarPkt_t*)ziamqdibacxe}, sypsknquhmzz, &ssbdydnaatik };
static const struct kdjigrgqrois wuxcqqkcczul = { {0, 1, 1, 0, 0, 0, 0}, 0x37, 113, {12, 44, 13, 44}, { 3, 3, 0x1e, 1, yesurpvnxprn }, { 3, 4, 0x07, 0, klwpsnaremnn }, { 3, 3, 0xe0, 5, gljwqnkgvonk }, { 0, 0, 0, 0, NULL }, &mvzwwwhtgarp, {.npikivgkyypz = (bc7215DataVarPkt_t*)ziamqdibacxe}, moagfmqignav, &wlqancmfqcej };
static const struct kdjigrgqrois btvmximcaurh = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xF0, 4, yesurpvnxprn }, { 1, 2, 0x07, 0, klwpsnaremnn }, { 1, 3, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)mtryxubuibzp}, laxvqrktwdxt, &fgjdpnnbjdzl };
static const struct kdjigrgqrois ohmphjtfdkce = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 120, {56, 64, 0, 0}, { 1, 1, 0xF0, 4, yesurpvnxprn }, { 1, 2, 0x07, 0, klwpsnaremnn }, { 1, 3, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)tevtnfjwtwtz}, laxvqrktwdxt, &fgjdpnnbjdzl };
static const struct kdjigrgqrois hzarpdynvehn = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0xF0, 4, yesurpvnxprn }, { 0, 4, 0x07, 0, tvqvmuaqqrvx }, { 0, 4, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)uwgsufqblxwz}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois uryvscmqvnnb = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0xF0, 4, yesurpvnxprn }, { 0, 4, 0x0f, 0, kdghctskeoas }, { 0, 4, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)uwgsufqblxwz}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois pakgkwlxshpl = { {0, 1, 0, 0, 0, 1, 0}, 0x34, 104, {40, 64, 0, 0}, { 1, 1, 0xfe, 1, zyjffvcebxgi }, { 1, 0, 0x0f, 0, gngliwbhzkwa }, { 1, 0, 0x70, 4, khcvmumszyne }, { 0, 0, 0, 0, NULL }, &ugcqvtmqebkh, {.tfdvcvkctfsw.dntwwzvcqjni= {{1, 3}, 6, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ifbevdpuzizy, NULL };
static const struct kdjigrgqrois hcolemynvbce = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 144, {56, 88, 0, 0}, { 1, 1, 0xF8, 3, iavmeixdhscu }, { 1, 2, 0x07, 0, klwpsnaremnn }, { 1, 3, 0x0f, 0, mksktcjliwhi }, { 1, 1, 0x01, 0, tsrnfzhmsuef }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)fhqlwpmaqxor}, laxvqrktwdxt, NULL };
static const struct kdjigrgqrois skegmkgfiyba = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 264, {56, 208, 0, 0}, { 1, 1, 0xF8, 3, iavmeixdhscu }, { 1, 2, 0x07, 0, klwpsnaremnn }, { 1, 3, 0x0f, 0, mksktcjliwhi }, { 1, 1, 0x01, 0, tsrnfzhmsuef }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)siaayeanmves}, laxvqrktwdxt, NULL };
static const struct kdjigrgqrois eymsudxnvgvd = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 64, {48, 16, 0, 0}, { 0, 3, 0xFF, 0, nsynuixoqddb }, { 0, 1, 0x0f, 0, gnxpzwysuqfg }, { 0, 1, 0xf0, 4, bmbbqcewasii }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 4, 0x40}}, lsfwjlkhaxkl, NULL };
static const struct kdjigrgqrois rxyleixlqrwu = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xF8, 3, iavmeixdhscu }, { 1, 2, 0x07, 0, klwpsnaremnn }, { 1, 3, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)mtryxubuibzp}, laxvqrktwdxt, NULL };
static const struct kdjigrgqrois csaoyocpkkyo = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 264, {24, 240, 0, 0}, { 1, 10, 0x3c, 2, yesurpvnxprn }, { 1, 22, 0x07, 0, hljquovxzgfh }, { 1, 22, 0x70, 4, faajsjsemavy }, { 1, 8, 0xff, 0, wasxtxuhoupi }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 24, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, cahpkfeydkxz, NULL };
static const struct kdjigrgqrois ttsbefnkxwqe = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 344, {24, 320, 0, 0}, { 1, 10, 0x3c, 2, yesurpvnxprn }, { 1, 22, 0x07, 0, hljquovxzgfh }, { 1, 22, 0x70, 4, faajsjsemavy }, { 1, 8, 0xff, 0, wasxtxuhoupi }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 24, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, cahpkfeydkxz, NULL };
static const struct kdjigrgqrois cxwzbjtsucyg = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 224, {56, 168, 0, 0}, { 1, 4, 0x3e, 1, gcajfekxbndx }, { 1, 3, 0x0f, 0, zszvtuujqvjr }, { 1, 6, 0x07, 0, uhkpvdynyvsa }, { 1, 2, 0x0f, 0, qivvfvgqtivc }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 10, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, lkgfpruratxp, &frdjidlpedio };
static const struct kdjigrgqrois umcokjydehoc = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 296, {24, 272, 0, 0}, { 1, 10, 0x3c, 2, yesurpvnxprn }, { 1, 22, 0x0f, 0, ktjpnggotfrz }, { 1, 22, 0x70, 4, qkovyyumaseg }, { 1, 8, 0xff, 0, wasxtxuhoupi }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 24, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, cahpkfeydkxz, NULL };
static const struct kdjigrgqrois qpjgvfopsgol = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 40, {40, 0, 0, 0}, { 0, 3, 0x0f, 0, tlvwpuqzrocu }, { 0, 2, 0x07, 0, gemltkeahgdn }, { 0, 2, 0x70, 4, mefowlgychxe }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, tsdqbxzeriog, NULL };
static const struct kdjigrgqrois pijmcwegzugw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0, 4, 0x70, 4, lwmbjanqpqpc }, { 0, 4, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 8}, 5, 0x41}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois fdcarhglohao = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 317, {5, 160, 152, 0}, { 2, 6, 0xfe, 1, gcajfekxbndx }, { 2, 5, 0x70, 4, fawtprpzhhee }, { 2, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL }, &wqsigdwrvhxv, {.tfdvcvkctfsw.dntwwzvcqjni = {{2, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{1, 3}, 11, 0x80}}, vlgwouoxxcaa, &dakwrsmftmti };
static const struct kdjigrgqrois hkkohiwmeyxc = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 200, {56, 144, 0, 0}, { 1, 10, 0x3e, 1, fsfcmbkqsvit }, { 1, 7, 0x70, 4, nmihyxtsufug }, { 1, 11, 0x70, 4, ugfettxtzvmu }, { 1, 6, 0x04, 2, tsrnfzhmsuef }, &dgngnfdsytli, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 7, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{1, 9}, 6, 0x04}}, wakpzpggevwl, NULL };
static const struct kdjigrgqrois nfrwzaaytelk = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 157, {5, 152, 0, 0}, { 1, 6, 0xfe, 1, gcajfekxbndx }, { 1, 5, 0x70, 4, fawtprpzhhee }, { 1, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL }, &eogngwbanwxf, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bspdaeureyvl, &zycyzppwoguf };
static const struct kdjigrgqrois tdylkejpbort = { {0, 1, 0, 0, 0, 1, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, yesurpvnxprn }, { 0x00, 2, 0x07, 0, gbcpixqwpgdw }, { 0, 0, 0xf0, 4, gxnkayorkkno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, yrtrkmxqktlt, NULL };
static const struct kdjigrgqrois ynsqhayeowme = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, nsynuixoqddb }, { 0, 1, 0x0F, 0, qvzisowsrvzp }, { 0, 1, 0xf0, 4, mzpabkrzmugx }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 7, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ggdszwtxsgur, NULL };
static const struct kdjigrgqrois pwwqgwuefxqu = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 286, {6, 64, 64, 152}, { 3, 6, 0xfe, 1, gcajfekxbndx }, { 3, 5, 0x70, 4, fawtprpzhhee }, { 3, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL }, &wtiilowhypxr, {.tfdvcvkctfsw.dntwwzvcqjni = {{3, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, preizmuhmxgq, &pmwszizmljxs };
static const struct kdjigrgqrois fgvqxfqylskx = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 4, 0x0f, 0, yesurpvnxprn }, { 0, 1, 0x70, 4, xjvbuhlajqgw }, { 0, 5, 0xe0, 5, kygodkepoucb }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0xc0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, gjczrrnciugo, NULL };
static const struct kdjigrgqrois mxyyuodkfsvy = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 96, {32, 32, 32, 0}, { 0, 2, 0xf0, 4, cgvksurxswjr }, { 0xC0, 3, 0x0f, 0, xrqmfcrohsmx }, { 0x40, 4, 0x0f, 0, pxrplmlbjsmu }, { 0, 4, 0xff, 0, eocelfpjdawu }, &mnuuqppzetxe, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, fdgzrisjvsnx, NULL };
static const struct kdjigrgqrois muwbsfibembc = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x0f, 0, yesurpvnxprn }, { 0, 9, 0xe0, 5, klwpsnaremnn }, { 0, 7, 0x60, 5, uxfnphantyno }, { 0, 5, 0x1f, 0, ulckrizgitgy }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 9}, 7, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0} }, wpbbehpommlp, NULL };
static const struct kdjigrgqrois hsstjljykcsa = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, yesurpvnxprn }, { 0, 5, 0x70, 4, jwbcjityfwac }, { 0, 4, 0x07, 0, yfsxyagqyajn }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 9}, 0, 0x03}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0} }, ybnpeclipoez, NULL };
static const struct kdjigrgqrois ggqjccroewop = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 72, {72, 0, 0, 0}, { 0, 6, 0xff, 0, nsynuixoqddb }, { 0, 1, 0x0F, 0, qvzisowsrvzp }, { 0, 1, 0xf0, 4, bmbbqcewasii }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 9}, 7, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0} }, babjaboxqjtq, NULL };
static const struct kdjigrgqrois efofrfvummit = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 1, 0x0f, 0, abiypmrtzxpm }, { 0x80, 1, 0xc0, 6, sdvufbysfqjr }, { 0, 1, 0x30, 4, uxfnphantyno }, { 0, 4, 0x02, 1, lngoeqphvnen }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0} }, ybnpeclipoez, NULL };
static const struct kdjigrgqrois yagnxlhryawp = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 128, {72, 56, 0, 0}, { 0, 6, 0xFF, 0, fqqkbgmarcmz }, { 0, 1, 0x0f, 0, qvzisowsrvzp }, { 0, 1, 0xf0, 4, mzpabkrzmugx }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 9}, 7, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0} }, gczqerlgwjae, NULL };
static const struct kdjigrgqrois cnmczudfhmky = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 2, 0xf0, 4, yesurpvnxprn }, { 0x40, 3, 0x1f, 0, mwxhncyyiyqh }, { 0x40, 4, 0xff, 0, pxrplmlbjsmu }, { 0, 2, 0x0c, 2, pttllbzvuwsn }, &ijhhcvhfkmzb, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 3, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0,3},3,0x10}}, rgjakmryrrwd, NULL };
static const struct kdjigrgqrois dmorhjuzhzos = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xff, 0, nsynuixoqddb }, { 0, 2, 0x07, 0, dfwugjfgfggl }, { 0, 2, 0x60, 5, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 9}, 1, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0} }, wpbbehpommlp, NULL };
static const struct kdjigrgqrois govsbifshdnc = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, yesurpvnxprn }, { 0, 6, 0x70, 4, klwpsnaremnn }, { 0, 6, 0x03, 0, szfgznqnnsmy }, { 0, 0, 0, 0, NULL }, &khxtegixwalv, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 9}, 1, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0} }, wpbbehpommlp, NULL };
static const struct kdjigrgqrois uakyqzyevrmr = { {1, 0, 0, 1, 1, 0, 0}, 0x35, 100, {100, 0, 0, 0}, { 0, 3, 0x0F, 0, yesurpvnxprn }, { 0, 4, 0x07, 0, jvnztqhtnffx }, { 0, 4, 0x70, 4, cjggoagxlxcb }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois dcrcclqcvagq = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x0f, 0, yesurpvnxprn }, { 0, 9, 0xe0, 5, klwpsnaremnn }, { 0, 7, 0xe0, 5, uxfnphantyno }, { 0, 5, 0xff, 0, ulckrizgitgy }, &ktuxxlzspgpa, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 7, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, kysxpyjrellz, NULL };
static const struct kdjigrgqrois pgorfewkupiq = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 192, {16, 80, 16, 80}, { 1, 0, 0xf0, 4, yesurpvnxprn }, { 1, 0, 0x07, 0, xxnbypnhwalr }, { 1, 8, 0xf0, 4, acudvgmiohqz }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 8}, 0, 0x82}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, yslsxyjazcti, NULL };
#ifndef _NO_DEPRECATED
const struct icejugalibdt swacmtoygryi = {NULL, &pgorfewkupiq, 1, 95};
#endif
static const struct kdjigrgqrois titqhveisrjm = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 96, {16, 80, 0, 0}, { 1, 0, 0xf0, 4, yesurpvnxprn }, { 1, 0, 0x07, 0, xxnbypnhwalr }, { 1, 8, 0xf0, 4, acudvgmiohqz }, { 0x80, 0, 0, 0, NULL },
#ifndef _NO_DEPRECATED
&jhtkmadhgsys,
#else
&goppveltigkj,
#endif
{.tfdvcvkctfsw.dntwwzvcqjni = {{1, 8}, 0, 0x82}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, ifbevdpuzizy, NULL };
static const struct kdjigrgqrois vesysmuzkxrf = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, cnvrmmtnbwib}, { 0, 6, 0x0f, 0, wpzrfibswrrh}, { 0, 8, 0x07, 0, mbjbojreykno}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois ozdgmusrqwqs = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 136, {136, 0, 0, 0}, { 0, 0x46, 0xFF, 0, ecnfemzkobsa }, { 0x0, 5, 0xf0, 4, vtxztbnmjowx }, { 0, 5, 0x0f, 0, qdhcshkfupkm }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 8, 0x20}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0}, 0, 0}}, gogvzhwuapbb, NULL };
static const struct kdjigrgqrois rqclwwnempln = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xf0, 4, yesurpvnxprn }, { 0, 3, 0x07, 0, gisktbnifqko }, { 0, 2, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,8}, 2, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois vqobzlpjjiff = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, yesurpvnxprn }, { 0, 0, 0x8C, 2, wlyyfelnkzfi }, { 0, 0, 0x03, 0, uhtggzmnvqwz }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,8}, 1, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, cljvrzgwybyf, NULL };
static const struct kdjigrgqrois scpyjcnenctw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 47, {47, 0, 0, 0}, { 0, 5, 0x1F, 0, zkxewdgxxczo }, { 0, 2, 0x0C, 2, nskpidmbcnjt }, { 0, 2, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,9}, 1, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois gzlvaqltfbus = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 30, {7, 8, 7, 8}, { 1, 0, 0x0F, 0, pvewsnmnbdki }, { 0, 0, 0x07, 0, zuyjppaxffro }, { 0, 0, 0x70, 4, irobojujhfyg }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,8}, 0, 0x35}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, mvkmtnkrwpfm, NULL };
static const struct kdjigrgqrois gxksjtupqyrv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x0F, 0, yesurpvnxprn }, { 0, 1, 0x30, 4, ywrteveinyvh }, { 0, 1, 0xc0, 6, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,8}, 1, 0x0c}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois hnatmvnzsbmz = { {1, 1, 1, 0, 0, 0, 0}, 0x32, 192, {48, 48, 48, 48}, { 0, 4, 0xf0, 4, oibwwdmldgns }, { 0x00, 4, 0x0c, 2, kvhxtlfrqrhg }, { 0x80, 2, 0xe0, 5, dgndpjpipgeb }, { 2, 2, 0xff, 0, cjoiotohpowo }, &wnpuxlawnbxv, {.npikivgkyypz = (const bc7215DataVarPkt_t*)uyemfivwhxzx}, ltxohdptrmwi, NULL };
static const struct kdjigrgqrois ssyttfdhmgwj = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 368, {64, 152, 152, 0}, { 1, 6, 0x1e, 1, yesurpvnxprn }, { 1, 5, 0x70, 4, fawtprpzhhee }, { 1, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, lmywjygqgufm, NULL };
static const struct kdjigrgqrois lpspfonofgai = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 40, {32, 8, 0, 0}, { 0, 2, 0x0F, 0, yesurpvnxprn }, { 0, 1, 0x07, 0, klwpsnaremnn }, { 0, 1, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,3}, 1, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bbraenilafou, NULL };
static const struct kdjigrgqrois jwneeevuuinp = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96,56, 0}, { 1, 1, 0xf0, 4, yesurpvnxprn }, { 1, 1, 0x07, 0, gisktbnifqko }, { 1, 0, 0x03, 0, uxfnphantyno }, { 2, 1, 0xff, 0, aghhidcycdjo }, &sqjmgdqyrytx, {.tfdvcvkctfsw.dntwwzvcqjni = {{2, 9}, 4, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, pqgspokxpjpv, &hijcteziksza };
static const struct kdjigrgqrois lxnjcnfcwwhh = { {0, 0, 0, 0, 0, 1, 0}, 0x36, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, nsynuixoqddb }, { 0, 1, 0x0F, 0, qvzisowsrvzp }, { 0, 1, 0xf0, 4, mzpabkrzmugx }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 7, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, babjaboxqjtq, &wsgdrhxlewqi };
static const struct kdjigrgqrois riqkjcrfkzyt = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 97, {96, 1, 0, 0}, { 0, 1, 0x0F, 0, yesurpvnxprn }, { 0, 4, 0x70, 4, lwmbjanqpqpc }, { 0, 4, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 8}, 5, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois ppxhlrrtomxz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, abiypmrtzxpm }, { 0, 0, 0x07, 0, ybpyvlaaytbg }, { 0, 0, 0xf0, 4, acudvgmiohqz }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, cljvrzgwybyf, NULL };
static const struct kdjigrgqrois npsgiuxrmgxw = { {0, 0, 0, 0, 0, 1, 0}, 0x36, 140, {140, 0, 0, 0}, { 0, 16, 0xff, 0, nsynuixoqddb }, { 0, 15, 0x70, 4, qvzisowsrvzp }, { 0, 15, 0x0f, 0, mzpabkrzmugx }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,3}, 14, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wnvjgyeegfkz, NULL };
static const struct kdjigrgqrois ctchgcyohjbz = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 5, 0xf0, 4, abiypmrtzxpm }, { 0, 4, 0x70, 4, obscdisokwwa }, { 0, 4, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,9}, 4, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wsqjfycjhjhm, NULL };
static const struct kdjigrgqrois ekpqcboxkfft = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {31, 31, 0, 0}, { 0, 3, 0x1e, 1, zkxewdgxxczo }, { 0, 0, 0xf0, 4, kxdkesgfinud }, { 0, 1, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 1, 0x20}}, xbgrirfpgybc, NULL };
static const struct kdjigrgqrois qltdtyyfardt = { {0, 1, 0, 1, 1, 1, 0}, 0x36, 262, {64, 64, 0, 0}, { 0, 6, 0xFF, 0, nsynuixoqddb }, { 0, 1, 0x0F, 0, qvzisowsrvzp }, { 0, 1, 0xf0, 4, mzpabkrzmugx }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 7, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{1, 3}, 2, 0x04}}, arfkjqielkhb, &derhlbxyjkaq };
static const struct kdjigrgqrois zcbhtmxhsuai = { {0, 1, 0, 0, 0, 0, 0}, 0x35, 201, {35,67,67,32}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0, 0, 0x07, 0, klwpsnaremnn }, { 0x82, 2, 0x70, 4, ugfettxtzvmu }, { 0, 0, 0x30, 4, xwpraoqjyriq }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ucewadkrfpts, NULL };
static const struct kdjigrgqrois pkcqiuicudrt = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 2, 0x7f, 0, uulrtvniqbbi }, { 0, 1, 0x70, 4, tmoapbkilvhx }, { 0, 7, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.npikivgkyypz=(const bc7215DataVarPkt_t*)pahapwkapoct}, fqmqmhxzkuiy, NULL };
static const struct kdjigrgqrois rjtdtifwfddh = { {0, 1, 0, 0, 0, 0, 1}, 0x34, 95, {22, 60, 8, 5}, { 1, 0, 0x1f, 0, xgajasxpvaaj }, { 0, 2, 0x38, 3, fmxgjfnrbqki }, { 1, 0, 0x60, 5, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &oecemaclykon, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 6, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, lrzvihwysyju, NULL };
static const struct kdjigrgqrois vsyovsemcyqm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 2, 0x1f, 0, xgajasxpvaaj }, { 0, 1, 0xE0, 5, uvujmtkcqoiv }, { 0, 2, 0xe0, 5, ullpmggbapds }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 3, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois xlmglueffnca = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 72, {16, 56, 0, 0}, { 1, 1, 0x0f, 0, qsjskffkkdso }, { 1, 0, 0x07, 0, ybqftvqsjyve }, { 1, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bspdaeureyvl, &offkkhbxnicg };
static const struct kdjigrgqrois irjptugwmjkp = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0xF0, 4, yesurpvnxprn }, { 0, 6, 0x07, 0, ybqftvqsjyve }, { 0, 6, 0x30, 4, pxrplmlbjsmu }, { 0, 7, 0x78, 3, yuikpzqrywzu }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &sfehycqllmim };
static const struct kdjigrgqrois bcgmlxkmltni = { {1, 1, 0, 0, 0, 0, 0}, 0x32, 256, {72, 72, 56, 56}, { 0, 5, 0xF0, 4, wcffplmknqjq }, { 0, 6, 0x07, 0, dfwugjfgfggl }, { 0, 6, 0xe0, 5, zycziltiqeqh }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 6, 0x07}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, kwntolvtjejo, NULL };
static const struct kdjigrgqrois pyylateuqiuz = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 2, 0x0f, 0, wcffplmknqjq }, { 0, 1, 0x07, 0, yrxjsauslprr }, { 0, 1, 0x18, 3, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, trsviwrdgzmk, NULL };
static const struct kdjigrgqrois ocrddalsncdz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0x0f, 0, yesurpvnxprn }, { 0, 2, 0x07, 0, klwpsnaremnn }, { 0, 2, 0x70, 4, ugfettxtzvmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ceihxzdoikdk, NULL };
static const struct kdjigrgqrois iwzpqcfsvhhx = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 3, 0x0f, 0, yesurpvnxprn }, { 0, 2, 0x07, 0, klwpsnaremnn }, { 0, 2, 0x70, 4, ugfettxtzvmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, chovbdoiwuhh, NULL };
static const struct kdjigrgqrois xjwodzreuejn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x0f, 0, wcffplmknqjq }, { 0, 6, 0x07, 0, cytfrmrvpryw }, { 0, 6, 0x70, 4, hfjfaictqjnj }, { 0, 5, 0x30, 4, lbxvxokwhdur }, &kmmjihktplmr, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, syivvqbzjvsn, NULL };
static const struct kdjigrgqrois fgnapobjzqqt = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x1e, 1, bjwkqubxshep }, { 0, 6, 0x0f, 0, zweqzhpfquul }, { 0, 6, 0x70, 4, hfjfaictqjnj }, { 0, 5, 0x30, 4, lbxvxokwhdur }, &kmmjihktplmr, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, syivvqbzjvsn, &dwxuoqwpdnuk };
static const struct kdjigrgqrois yjczyurvkfgs = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x0f, 0, abiypmrtzxpm }, { 0, 6, 0x07, 0, cytfrmrvpryw }, { 0, 6, 0x70, 4, hfjfaictqjnj }, { 0, 5, 0x30, 4, lbxvxokwhdur }, &zbceoaavueaz, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, syivvqbzjvsn, NULL };
static const struct kdjigrgqrois fxtbeamwutah = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 96, {32, 32, 32, 0}, { 1, 1, 0xf0, 4, wcffplmknqjq }, { 1, 1, 0x07, 0, cytfrmrvpryw }, { 1, 2, 0x70, 4, ugfettxtzvmu }, { 1, 3, 0x03, 0, lbxvxokwhdur }, &novrfvwupkjk, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, kodnvjxczgca, NULL };
static const struct kdjigrgqrois uiefcghuzoiw = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 1, 0xF0, 4, wcxlbzbhtwjv }, { 0, 0, 0xe0, 5, ezndejkzdwby }, { 0, 0, 0x0c, 2, izjqcngmafuk }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0,8}, 0, 0x00}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ybnpeclipoez, NULL };
static const struct kdjigrgqrois tczgbnrvjaaa = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 5, 0x0f, 0, yesurpvnxprn }, { 0, 3, 0x0e, 1, qbfgmvevkgcr }, { 0, 6, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 3, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois fhsiewsdazly = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, tlvwpuqzrocu }, { 0, 6, 0x0f, 0, zsbjpadkqkhk }, { 0, 8, 0x07, 0, mbjbojreykno }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bbraenilafou, NULL };
static const struct kdjigrgqrois hbeybynugvlv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, nsynuixoqddb }, { 0, 6, 0x0f, 0, zsbjpadkqkhk }, { 0, 8, 0x07, 0, mbjbojreykno }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois bizqxgqhvkgt = { {0, 1, 0, 0, 0, 1, 0}, 0x30, 64, {32, 32, 0, 0}, { 0, 0, 0x0f, 0, abiypmrtzxpm }, { 0, 2, 0x07, 0, iynzkgbhspof }, { 0, 0, 0xf0, 4, bmbbqcewasii }, { 0, 0, 0, 0, NULL }, &nqzynfrdqgyx, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ugoquwtumcry, NULL };
static const struct kdjigrgqrois qknxnqlbujgc = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 2, 0xf0, 4, abiypmrtzxpm }, { 0, 3, 0x07, 0, npecguqhfkkt }, { 0, 3, 0x70, 4, fqqkwwpykiir }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 8}, 2, 0xb8}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, pjielnujmval, NULL };
static const struct kdjigrgqrois miiytmxzjqxo = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 5, 0x0f, 0, yesurpvnxprn }, { 0, 2, 0xe0, 5, klwpsnaremnn }, { 0, 5, 0x60, 5, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ndxnkykbmyop, NULL };
static const struct kdjigrgqrois hnsootgmwvyv = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 312, {160, 152, 0, 0}, { 1, 6, 0xfe, 1, gcajfekxbndx }, { 1, 5, 0x70, 4, fawtprpzhhee }, { 1, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL }, &vuquyzbxithi, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 6, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{1, 9}, 5, 0x01}}, wakpzpggevwl, &zycyzppwoguf };
static const struct kdjigrgqrois wqgnclorhdli = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 160, {56, 104, 0, 0}, { 1, 9, 0x3E, 1, fsfcmbkqsvit }, { 1, 5, 0x70, 4, lujrsilsbltr }, { 1, 10, 0x0f, 0, mscfzyeboixu }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bspdaeureyvl, NULL };
static const struct kdjigrgqrois xivdfecolbcb = { {0, 1, 0, 0, 0, 0, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, abiypmrtzxpm }, { 0x00, 2, 0x07, 0, tzgxzqkfiben }, { 0, 0, 0xf0, 4, gxnkayorkkno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, yrtrkmxqktlt, NULL };
static const struct kdjigrgqrois rvqaeffvvuyj = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0xff, 0, zzwjugygfzah }, { 0x00, 0, 0x07, 0, klwpsnaremnn }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &vuvobcgmcjoa, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois doccpadnzytt = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 72, {72, 0, 0, 0}, { 0, 6, 0xff, 0, fqqkbgmarcmz }, { 0, 1, 0x0F, 0, qvzisowsrvzp }, { 0, 1, 0xf0, 4, mzpabkrzmugx }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 9}, 7, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0} }, babjaboxqjtq, NULL };
static const struct kdjigrgqrois huvvedhkvclf = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x1f, 0, xgajasxpvaaj }, { 0x80, 3, 0x30, 4, pnkrgohcdztf }, { 0, 3, 0x03, 0, xxnpenfefvwy }, { 0, 2, 0xff, 0, fmhivgbvipdk }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)cxohkmokmyfq }, fqmqmhxzkuiy, NULL };
static const struct kdjigrgqrois kiudswjbdlso = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 1, 0x1f, 0, xgajasxpvaaj }, { 0x80, 3, 0x30, 4, pnkrgohcdztf }, { 0, 3, 0x03, 0, xxnpenfefvwy }, { 0, 2, 0xff, 0, nicpsennhqme }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)dhksosdzslzz }, fqmqmhxzkuiy, NULL };
static const struct kdjigrgqrois vvmheedajore = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 4, 0x0f, 0, eljzwfefkbgl }, { 0, 4, 0x30, 4, eyqyhfzdrvxx }, { 0, 2, 0x07, 0, fbqfpruwxawg }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 9}, 4, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois ygzugiyaengv = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0x0f, 0, zkxewdgxxczo }, { 0, 4, 0x18, 3, ajabnpypxszy }, { 0, 4, 0x07, 0, ebksofhlgkpa }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 3}, 4, 0x20}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois zspvgsdokutk = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0xf0, 4, zkxewdgxxczo }, { 0, 2, 0x07, 0, xxosrxtozcbu }, { 0, 0, 0x18, 3, rigdugjowjha }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois cxpnietqgvia = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0xf0, 4, zkxewdgxxczo }, { 0, 2, 0x03, 0, ajabnpypxszy }, { 0, 0, 0x18, 3, rigdugjowjha }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois bemtzoiriqos = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 4, 0xf0, 4, zkxewdgxxczo }, { 0x0, 4, 0x07, 0, nagzypxufjsh }, { 0, 2, 0x70, 4, ebksofhlgkpa }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0,3},4,0x08}}, flpszvfgkfpq, NULL };
static const struct kdjigrgqrois xjymijmytrye = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, wcffplmknqjq }, { 0x0, 2, 0x70, 4, lrpdggnbestj }, { 0, 1, 0x70, 4, veqpimicnwaj }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, abjpqmkybtzk, NULL };
static const struct kdjigrgqrois xuysuvuuailw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 152, {152, 0, 0, 0}, { 0, 6, 0x3e, 1, xgajasxpvaaj }, { 0x80, 5, 0xe0, 5, zuyjppaxffro }, { 0, 5, 0x0c, 2, xxnpenfefvwy }, { 0, 6, 0x80, 7, lngoeqphvnen }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 9}, 8, 0x20}}, vwseaoclbrqg, &vejsakfloial };
static const struct kdjigrgqrois fqjmiiuskpqc = { {0, 1, 1, 0, 0, 0, 0}, 0x37, 113, {12, 45, 12, 44}, { 3, 3, 0x0f, 0, yesurpvnxprn }, { 3, 4, 0x07, 0, klwpsnaremnn }, { 3, 3, 0xe0, 5, gljwqnkgvonk }, { 0, 0, 0, 0, NULL }, &mvzwwwhtgarp, {.npikivgkyypz = (bc7215DataVarPkt_t*)ziamqdibacxe}, sypsknquhmzz, NULL };
static const struct kdjigrgqrois kfysfmvcdnin = { {1, 1, 1, 0 , 0, 0, 0}, 0x36, 160, {80, 80, 0, 0}, { 0, 5, 0xf0, 4, wcffplmknqjq}, { 0, 6, 0x07, 0, dfwugjfgfggl}, { 0, 6, 0xC0, 6, gxxnsdixsthv }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)prlsxzcwdtec}, nxeyakvojjes, NULL };
static const struct kdjigrgqrois vgssvcotncma = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 3, 0x0f, 0, yesurpvnxprn }, { 0, 1, 0x0f, 0, jaobzjsamwcf }, { 0, 1, 0xe0, 5, zdaxnykiemnp }, { 0, 6, 0x1f, 0, nemdennzmnye }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois ibsxhdsowrqu = { {0, 1, 1, 0, 0, 0, 0}, 0x32, 192, {96, 48, 48, 0}, { 1, 4, 0x0f, 0, eljzwfefkbgl }, { 1, 4, 0x30, 4, eyqyhfzdrvxx }, { 1, 2, 0x07, 0, fbqfpruwxawg }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.npikivgkyypz = (const bc7215DataVarPkt_t*)bzijxlazacti}, nboovnfjkgfx, NULL };
static const struct kdjigrgqrois nktgtfnpxkhn = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 161, {56, 104, 1, 0}, { 1, 9, 0xFE, 1, bjwkqubxshep }, { 1, 5, 0x70, 4, lujrsilsbltr }, { 1, 10, 0x0f, 0, mscfzyeboixu }, { 0, 0, 0, 0, NULL}, &eogngwbanwxf, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bspdaeureyvl, NULL };
static const struct kdjigrgqrois jgowmjqvzngf = { {1, 0, 0, 0, 0, 0, 0}, 0x36, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, yesurpvnxprn }, { 0x0, 5, 0x70, 4, szfgznqnnsmy }, { 0, 4, 0x07, 0, icgmlvzoyhwj }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x03}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ybnpeclipoez, NULL };
static const struct kdjigrgqrois sjshlmeutilm = { {1, 0, 0, 0, 0, 0, 0}, 0x36, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, yesurpvnxprn }, { 0x40, 5, 0xf0, 4, syvkgjpcbbei }, { 0, 5, 0xf0, 4, ilwsoyzatyov }, { 0, 0, 0, 0, NULL }, &lnbjpwimzvur, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x03}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 0, 0x80}}, ybnpeclipoez, NULL };
static const struct kdjigrgqrois atpdkmjgogzr = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, yesurpvnxprn }, { 0x40, 5, 0xf0, 4, syvkgjpcbbei }, { 0, 5, 0xf0, 4, ilwsoyzatyov }, { 0, 0, 0, 0, NULL }, &lnbjpwimzvur, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x03}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 0, 0x80}}, ybnpeclipoez, NULL };
#ifndef _NO_DEPRECATED
const struct icejugalibdt iibybupntnth = {NULL, &xmyrzlaktydf, 2, 165};
static const struct kdjigrgqrois cciruoeyyuli = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0xf0, 4, xyulyfqvekqy }, { 0x00, 1, 0x0c, 2, kowbieqwlbpm }, { 0, 1, 0x03, 0, uhtggzmnvqwz }, { 0x80, 2, 0xf0, 4, hvkesnuxkauc }, &fuhksixhygsp, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,9},0,0x08}}, jlledcdowuhe, NULL };
const struct icejugalibdt cspimwcqitrf = {NULL, &blhbhbjngidd, 2, 165};
static const struct kdjigrgqrois mpbaqkcufixu = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0xf0, 4, zkxewdgxxczo }, { 0x00, 1, 0x0c, 2, kowbieqwlbpm }, { 0, 1, 0x03, 0, uhtggzmnvqwz }, { 0x80, 2, 0xf0, 4, coadwkqmwcoz }, &owkktceyoynf, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,9},0,0x10}}, jlledcdowuhe, NULL };
const struct icejugalibdt cbanstcjfvok = {NULL, &gdlxkzwqlgjm, 2, 165};
static const struct kdjigrgqrois nnawposflmbi = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0xf0, 4, zkxewdgxxczo }, { 0x00, 1, 0x0c, 2, kowbieqwlbpm }, { 0, 1, 0x03, 0, uhtggzmnvqwz }, { 0x80, 2, 0xf0, 4, hvkesnuxkauc }, &lvoxlyzzgjvt, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,9},0,0x08}}, jlledcdowuhe, NULL };
const struct icejugalibdt xutuqlojlsvg = {NULL, &sswomsklwbzb, 2, 165};
static const struct kdjigrgqrois wcvsnaxbvase = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0xf0, 4, wcffplmknqjq }, { 0x00, 1, 0x0c, 2, kowbieqwlbpm }, { 0, 1, 0x03, 0, uhtggzmnvqwz }, { 0x80, 2, 0xf0, 4, coadwkqmwcoz }, &yyxvfdvqytvh, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,9},0,0x10}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois hdqcsbidntks = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, xptmjzvcndup }, { 0xc0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, kwjrkdphyxwx, NULL };
static const struct kdjigrgqrois vohyjumcigco = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, lxypqzemwbcv }, { 0xc0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, lvmiyfinpvbq, NULL };
#endif
static const struct kdjigrgqrois xrgleqhjsmyl = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x0f, 0, yesurpvnxprn }, { 0, 1, 0xF0, 4, wnwydwbjshnc }, { 0, 1, 0x0F, 0, bmbbqcewasii }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0X80}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois ggzadtlaewgk = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 2, 0xf0, 4, zkxewdgxxczo }, { 1, 2, 0x07, 0, nagzypxufjsh }, { 1, 4, 0xe0, 5, wxeenrqzpzbd }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 3}, 2, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, tmpyrvtulwjk, NULL };
static const struct kdjigrgqrois xcquheqwijlx = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, cgvksurxswjr }, { 0, 0, 0x07, 0, klwpsnaremnn}, { 0, 0, 0x30, 4, pxrplmlbjsmu}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois bxaqdjefufbv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, abiypmrtzxpm }, { 0, 0, 0x07, 0, klwpsnaremnn}, { 0, 0, 0x30, 4, pxrplmlbjsmu}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois jkqfjlqiojkc = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 144, {16, 56, 16, 56}, { 1, 3, 0xf0, 4, yesurpvnxprn }, { 1, 0, 0xF0, 4, zkdvdrtxxrhx }, { 1, 1, 0x30, 4, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0Xf0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, fwblxfqxsysj, NULL };
static const struct kdjigrgqrois yujlzixtceuy = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 160, {16, 64, 16, 64}, { 1, 3, 0xf0, 4, yesurpvnxprn }, { 1, 0, 0xF0, 4, zkdvdrtxxrhx }, { 1, 1, 0x30, 4, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0Xf0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, fwblxfqxsysj, NULL };
static const struct kdjigrgqrois nduavsnvorto = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 48, {24, 24, 0, 0}, { 0, 2, 0x0f, 0, cgvksurxswjr }, { 0, 2, 0x70, 4, lrpdggnbestj }, { 0, 1, 0x70, 4, cjggoagxlxcb }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 8}, 2, 0xa7}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, abjpqmkybtzk, NULL };
static const struct kdjigrgqrois mqwmrkgztcks = { {0, 1, 0, 0, 0, 1, 0}, 0x21, 102, {34, 34, 34, 0}, { 0, 1, 0x1E, 1, abiypmrtzxpm }, { 0, 0, 0x70, 4, nkvykjwizqni }, { 0, 0, 0x0c, 2, rigdugjowjha }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 8}, 0, 0x9c}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, hfqueeoveodi, NULL };
static const struct kdjigrgqrois zkcosrhlskoq = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 100, {50, 50, 0, 0}, { 0, 3, 0x78, 3, zkxewdgxxczo }, { 0x80, 0, 0x0c, 2, jhpavfqdtmow }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 4, 0xff, 0, xqeqkijkquem }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 9}, 5, 0x30}}, xbgrirfpgybc, NULL };
static const struct kdjigrgqrois bdfqbuizkmhj = { {0, 0, 0, 0, 0, 1, 0}, 0x30, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, nsynuixoqddb }, { 0, 1, 0x0F, 0, qvzisowsrvzp }, { 0, 1, 0xf0, 4, mzpabkrzmugx }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 7, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, babjaboxqjtq, &wsgdrhxlewqi };
static const struct kdjigrgqrois dptpmwgklgie = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, tlvwpuqzrocu}, { 0, 6, 0x0f, 0, zsbjpadkqkhk}, { 0, 8, 0x07, 0, jkswdfgufkca }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois hsklalvkhmxg = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 17, {16, 1, 0, 0}, { 0, 1, 0xF8, 3, uligrmwovbln }, { 0, 1, 0x07, 0, klwpsnaremnn }, { 0, 0, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 0, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, udiahqzowpry, NULL };
static const struct kdjigrgqrois imvenpourfsd = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 5, 0x0f, 0, abiypmrtzxpm }, { 0, 4, 0x70, 4, klwpsnaremnn }, { 0, 4, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 3, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, nzdrvqfocyei, NULL };
static const struct kdjigrgqrois aeiuewwzfolw = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 2, 0xf0, 4, cgvksurxswjr }, { 0, 3, 0x07, 0, qbfgmvevkgcr }, { 0, 3, 0x70, 4, fqqkwwpykiir }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, cqlqzezqqdqf, NULL };
static const struct kdjigrgqrois erytzuscorjo = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, yesurpvnxprn}, { 0, 0, 0x07, 0, klwpsnaremnn}, { 0, 3, 0x03, 0, pxrplmlbjsmu}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois pgdjhacaewel = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 176, {112, 64, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0, 7, 0xe0, 5, osnwjoweeogm }, { 0, 5, 0xe0, 5, qawevoxbehgi }, { 0, 12, 0x07, 0, hrrwiswieqyp }, &xuspgpyovgdx, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wakpzpggevwl, NULL };
static const struct kdjigrgqrois irmggcdbnyyn = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 56, {8, 48, 0, 0}, { 1, 2, 0x0f, 0, yesurpvnxprn }, { 1, 0, 0x0f, 0, aroekziciyls }, { 1, 1, 0x07, 0, pksciaxzldqs }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, laxvqrktwdxt, NULL };
static const struct kdjigrgqrois lonehgasbcqv = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 56, {8, 48, 0, 0}, { 1, 2, 0x7E, 1, nfhmibmlxsnc }, { 1, 0, 0x0f, 0, aroekziciyls }, { 1, 1, 0x07, 0, pksciaxzldqs }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, laxvqrktwdxt, &levrxybwiqno };
static const struct kdjigrgqrois gpkebkecfcdw = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, qsjskffkkdso }, { 1, 1, 0x07, 0, gisktbnifqko }, { 1, 0, 0x03, 0, uxfnphantyno }, { 2, 1, 0xff, 0, gkkstosamumn }, &zlzgpqkuxdqk, {.tfdvcvkctfsw.dntwwzvcqjni = {{2, 9}, 4, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, pqgspokxpjpv, &kaduikdcfhdi };
static const struct kdjigrgqrois bktxhdlsrkvv = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, yesurpvnxprn }, { 0x0, 5, 0x70, 4, szfgznqnnsmy }, { 0, 4, 0x07, 0, cjggoagxlxcb }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ybnpeclipoez, NULL };
static const struct kdjigrgqrois gribyoljwnok = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfe, 1, gcajfekxbndx }, { 3, 5, 0x70, 4, fawtprpzhhee }, { 3, 8, 0xf0, 4, rooptcylbuyn }, { 0, 0, 0, 0, NULL }, &eogngwbanwxf, {.tfdvcvkctfsw.dntwwzvcqjni = {{3, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{3, 9}, 9, 0x0f}}, preizmuhmxgq, &rhycpdaodrak };
static const struct kdjigrgqrois vrflmzrbjtjb = { {0, 1, 0, 0 ,0, 0, 0}, 0x36, 216, {64, 152, 0, 0}, { 1, 6, 0xff, 0, nqbpxohgetod }, { 1, 5, 0x70, 4, lujrsilsbltr }, { 1, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL}, &gnhrkilfvuvu, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, wakpzpggevwl, NULL };
static const struct kdjigrgqrois ftkrobveanxx = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 317, {5, 160, 152, 0}, { 2, 6, 0xfe, 1, gcajfekxbndx }, { 2, 5, 0x70, 4, fawtprpzhhee }, { 2, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL }, &wqsigdwrvhxv, {.tfdvcvkctfsw.dntwwzvcqjni = {{2, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{1, 3}, 12, 0x80}}, rxyfwfxpxesp, NULL };
static const struct kdjigrgqrois farxtgpfdtkj = { {0, 1, 0, 0, 0, 1, 0}, 0x30, 128, {64, 64, 0, 0}, { 0, 6, 0xff, 0, nsynuixoqddb }, { 0, 1, 0x0f, 0, qvzisowsrvzp }, { 0, 1, 0xf0, 4, mzpabkrzmugx }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 7, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, babjaboxqjtq, &wsgdrhxlewqi };
static const struct kdjigrgqrois jahotgecgbrb = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 424, {24, 400, 0, 0}, { 1, 10, 0x3c, 2, yesurpvnxprn }, { 1, 22, 0x07, 0, hljquovxzgfh }, { 1, 22, 0x70, 4, qkovyyumaseg }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 24, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, tmpyrvtulwjk, NULL };
static const struct kdjigrgqrois ifjvrjjgsvpu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0xff, 0, nsynuixoqddb }, { 0, 0, 0x07, 0, jtaryvaqudln }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0x80, 0, 0, 0, NULL },
#ifndef _NO_DEPRECATED
&vguywtawfqau,
#else
&goppveltigkj,
#endif
{.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0,8},1,0x16}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois pzakyjdtwkhp = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 64, {20, 44, 0, 0}, { 1, 0, 0xf0, 4, yesurpvnxprn }, { 1, 0, 0x03, 0, xkzkwxgbkbwf }, { 1, 0, 0x0c, 2, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 2, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, gizttlubtqim, NULL };
static const struct kdjigrgqrois nshwimhyqjdg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x0f, 0, wcffplmknqjq }, { 0, 2, 0x0e, 1, ybpyvlaaytbg }, { 0, 1, 0x60, 5, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &rjtdbpunizmw, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois kzopmwvqfhif = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 192, {32, 160, 0, 0}, { 1, 6, 0x1e, 1, yesurpvnxprn }, { 1, 4, 0x07, 0, qyadwftjvequ }, { 1, 8, 0x07, 0, btjmcnhdbjhv }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 2, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, tmpyrvtulwjk, NULL };
static const struct kdjigrgqrois audymxwdevcq = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 80, {80, 0, 0, 0}, { 0, 3, 0x0f, 0, yesurpvnxprn }, { 0, 1, 0x0f, 0, jaobzjsamwcf }, { 0, 1, 0xe0, 5, zdaxnykiemnp }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bbraenilafou, NULL };
static const struct kdjigrgqrois sbfnuegopgkd = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 56, {56, 0, 0, 0}, { 0, 2, 0x1f, 0, wgrzvmgvxdbc }, { 0, 1, 0x03, 0, lmnidopusvcf }, { 0, 1, 0x38, 3, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &znbhexqwyyix };
static const struct kdjigrgqrois raqywvkfkrda = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 120, {56, 64, 0, 0}, { 1, 1, 0xF0, 4, yesurpvnxprn }, { 1, 2, 0x07, 0, klwpsnaremnn }, { 1, 3, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)lcanhfiubhqa}, laxvqrktwdxt, NULL };
static const struct kdjigrgqrois hhoulpxmjvom = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 56, {12, 44, 0, 0}, { 1, 3, 0x0f, 0, yesurpvnxprn }, { 1, 4, 0x07, 0, klwpsnaremnn }, { 1, 3, 0xe0, 5, gljwqnkgvonk }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x03}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, uviddcgaqelg, NULL };
static const struct kdjigrgqrois dultzplshqsr = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 140, {140, 0, 0, 0}, { 0, 16, 0xFF, 0, nsynuixoqddb }, { 0, 15, 0xf0, 4, qvzisowsrvzp }, { 0, 15, 0x0f, 0, mzpabkrzmugx }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 14, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wnvjgyeegfkz, NULL };
static const struct kdjigrgqrois djcwzivlgnlx = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 128, {112, 16, 0, 0}, { 0, 3, 0x3C, 2, yesurpvnxprn }, { 0x80, 2, 0x0e, 1, lwmbjanqpqpc }, { 0, 2, 0x70, 4, nwkdkamttlvn }, { 0, 3, 0x02, 1, fcnzlwhyougv }, &fyxhffgoainf, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois etxtpjkzwtzj = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 64, {48, 16, 0, 0}, { 0, 1, 0x0f, 0, abiypmrtzxpm }, { 0, 1, 0xc0, 6, sdvufbysfqjr }, { 0x80, 1, 0x30, 4, uxfnphantyno }, { 1, 0, 0x07, 0, spfikypxoocg }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, zjdweqorplwt, NULL };
static const struct kdjigrgqrois mwnajsafjmcn = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 46, {46, 0, 0, 0}, { 0, 3, 0x0f, 0, yesurpvnxprn }, { 0, 1, 0x07, 0, tvqvmuaqqrvx }, { 0, 2, 0x70, 4, ugfettxtzvmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x38}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, dmlyzcgbmdyq, NULL };
static const struct kdjigrgqrois kjqekvbuobix = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1f, 0, xgajasxpvaaj }, { 0, 4, 0x1f, 2, nclkbzyijjmp }, { 0, 4, 0x03, 0, xxnpenfefvwy }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 5, 0x40}}, fqmqmhxzkuiy, NULL };
static const struct kdjigrgqrois maycgrfalbek = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1f, 0, xgajasxpvaaj }, { 0, 4, 0x70, 4, tjonhriptfeb }, { 0, 4, 0x03, 0, xxnpenfefvwy }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 3}, 5, 0x40}}, fqmqmhxzkuiy, NULL };
static const struct kdjigrgqrois khktjforhcvq = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x0f, 0, abiypmrtzxpm }, { 0, 5, 0xe0, 5, klwpsnaremnn }, { 0, 7, 0x60, 5, uxfnphantyno }, { 0, 1, 0xf0, 4, xmcrzrykkuhz }, &rjtdbpunizmw, {.tfdvcvkctfsw.dntwwzvcqjni={{0, 9}, 3, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0} }, wpbbehpommlp, NULL };
static const struct kdjigrgqrois aadrxmlcismv = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, abiypmrtzxpm }, { 0, 1, 0x07, 0, rhhlairhixpb }, { 0, 2, 0x07, 0, btjmcnhdbjhv }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0xc0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0}, 0, 0}}, zkbzupvwkovr, NULL };
static const struct kdjigrgqrois qhgblsrwcbmn = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {23, 8, 23, 8}, { 1, 0, 0x78, 3, yesurpvnxprn }, { 0, 0, 0x38, 3, klwpsnaremnn }, { 1, 0, 0x07, 0, khcvmumszyne }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0}, 0, 0}}, mvkmtnkrwpfm, NULL };
static const struct kdjigrgqrois hopmureetzpb = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {25, 6, 25, 6}, { 1, 0, 0x0f, 0, tlvwpuqzrocu }, { 0, 0, 0xe0, 5, npecguqhfkkt }, { 0, 1, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0}, 0, 0}}, mvkmtnkrwpfm, NULL };
static const struct kdjigrgqrois abuaqrvjafyo = { {0, 1, 0, 0, 0, 0, 0}, 0x3C, 85, {76, 9, 0, 0}, { 0, 2, 0xFF, 0, nsynuixoqddb }, { 0, 0, 0x70, 4, wuhxjlaconjm }, { 0, 1, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 1}, 0, 0x0F}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0}, 0, 0}}, tvgktsaxfjel, NULL };
static const struct kdjigrgqrois mevxayilakqy = { {0, 1, 0, 0, 0, 1, 0}, 0x36, 86, {43, 43, 0, 0}, { 0, 2, 0xf0, 4, zkxewdgxxczo }, { 0x80, 0, 0x0c, 2, jhpavfqdtmow }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 4, 0x30, 4, nxgxuxcdjbao }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 0, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, xbgrirfpgybc, NULL };
static const struct kdjigrgqrois yylprirnggpg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 10, 0x7c, 2, abiypmrtzxpm }, { 0, 6, 0xe0, 5, osnwjoweeogm}, { 0, 4, 0xe0, 5, qawevoxbehgi}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 9, 0x20}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &yioyrieypquj };
static const struct kdjigrgqrois dmsohjyoajbz = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 2, 0x1e, 1, qsjskffkkdso }, { 0, 1, 0x07, 0, yrxjsauslprr }, { 0, 1, 0x38, 3, dilswyxodmcr }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, trsviwrdgzmk, &nwtxnitqmkzb };
static const struct kdjigrgqrois jpwiwimpbenw = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x1e, 1, zkxewdgxxczo }, { 0x0, 8, 0xe0, 5, nagzypxufjsh }, { 0, 6, 0x70, 4, ebksofhlgkpa }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 6, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, flpszvfgkfpq, &jenyyyjfprpf };
static const struct kdjigrgqrois kzmrfqcsuqiv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x7e, 1, blapmzvtxfpb }, { 0x0, 6, 0x0f, 0, byncdlnkbwuv }, { 0, 8, 0x07, 0, khcvmumszyne }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &ueeykihfhczt };
static const struct kdjigrgqrois hxeqwlkckhpl = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 33, {1, 32, 0, 0}, { 1, 0, 0x1e, 1, wcffplmknqjq }, { 1, 1, 0xe0, 5, ybpyvlaaytbg }, { 1, 0, 0x60, 5, uhtggzmnvqwz }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, zazglgqbjutv, &vncxgoxnufyo };
static const struct kdjigrgqrois cefhzlctfnnf = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x1e, 1, xyulyfqvekqy }, { 0x80, 6, 0x07, 0, nskpidmbcnjt }, { 0, 8, 0x07, 0, mbjbojreykno }, { 0, 8, 0xc0, 6, gsgscnoyofai }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &jfkhlpharckt };
static const struct kdjigrgqrois fsisdblgxpaq = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 108, {36, 36, 36, 0}, { 0, 2, 0xf0, 4, wcffplmknqjq }, { 0, 3, 0x0c, 2, ajabnpypxszy }, { 0, 3, 0x03, 0, bmbbqcewasii }, { 0, 2, 0x0c, 2, sgsofgdeuphx }, &xafesltoxsdj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, hfqueeoveodi, &cpgzscnqcwln };
static const struct kdjigrgqrois jkuhcgycrevh = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x1e, 1, wcffplmknqjq }, { 0x0, 9, 0xe0, 5, klwpsnaremnn }, { 0, 7, 0x60, 5, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 7, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &mqjxhpdfkogx };
static const struct kdjigrgqrois vceccfmcuxuy = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {56, 120, 0, 0}, { 1, 10, 0x7e, 1, blapmzvtxfpb }, { 0x81, 7, 0x70, 4, ttywxwiboswj }, { 1, 11, 0x70, 4, ugfettxtzvmu }, { 1, 5, 0xF0, 4, trrckuxciqru }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 7, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, wakpzpggevwl, &wdpzrbawyaeh };
static const struct kdjigrgqrois cddiqjejjoaj = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x1e, 1, mftyhtmppicz }, { 0, 2, 0x06, 1, zkbwbzcqcsfl }, { 0, 1, 0xc0, 6, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, jlledcdowuhe, &yqcljgihltxd };
static const struct kdjigrgqrois pubqtrkuwbee = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x7e, 1, blapmzvtxfpb }, { 0, 1, 0xf0, 4, wnwydwbjshnc }, { 0, 1, 0x0F, 0, bmbbqcewasii }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, jlledcdowuhe, &zgdshureeylg };
static const struct kdjigrgqrois glcbnytvqqjg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 9, 0x0f, 0, yesurpvnxprn }, { 0, 6, 0x7f, 0, epdennojosof }, { 0, 7, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, wpbbehpommlp, &nxvwddljsssp };
static const struct kdjigrgqrois jjssohfwandu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 0, 0x1e, 1, iomplekazizk }, { 0x80, 1, 0x03, 0, lilljgxuegds }, { 0, 1, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0x60, 5, ajabnpypxszy }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, wpbbehpommlp, &hhdbovujarvl };
static const struct kdjigrgqrois ogxmlmmyglbz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 2, 0x1e, 1, yesurpvnxprn }, { 0, 1, 0x70, 4, tmoapbkilvhx }, { 0, 7, 0x03, 0, yhxfbsyfdnrs }, { 0, 1, 0x0c, 2, vxbhzwnjxvln }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 0}, 0, 0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, jlledcdowuhe, &kanbxgrimqos };
static const struct kdjigrgqrois hkzqbyymzhyv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 1, 0x7e, 1, nfhmibmlxsnc }, { 0, 0, 0x70, 4, cybnccymaorr }, { 0, 0, 0x07, 0, fbqfpruwxawg }, { 0, 5, 0x70, 4, iabcprrjchhd }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0x09}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, wpbbehpommlp, &tcozbxwdupxg };
static const struct kdjigrgqrois wvwqadyowlmq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 2, 0x7e, 1, blapmzvtxfpb }, { 0, 1, 0x70, 4, cybnccymaorr }, { 0, 1, 0x07, 0, dilswyxodmcr }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, fqmqmhxzkuiy, &nwtxnitqmkzb };
static const struct kdjigrgqrois vuvoabrglioa = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xf8, 3, fsfcmbkqsvit }, { 1, 2, 0x07, 0, klwpsnaremnn }, { 1, 3, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.npikivgkyypz = (bc7215DataVarPkt_t*)mtryxubuibzp}, laxvqrktwdxt, &awfglgyaukwx };
static const struct kdjigrgqrois awadfwojufyt = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 68, {68, 0, 0, 0}, { 0, 1, 0x0e, 1, dayiqypyjymc }, { 0, 0, 0x07, 0, klwpsnaremnn }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, jlledcdowuhe, &xtmvrhflocpb };
static const struct kdjigrgqrois hulypnpuywaf = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 7, 0xe0, 5, osnwjoweeogm }, { 0, 5, 0xe0, 5, qawevoxbehgi }, { 0, 12, 0x07, 0, hrrwiswieqyp }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &pesaoochqbkt };
static const struct kdjigrgqrois sdwxcahnlksc = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 1, 0xf0, 4, yesurpvnxprn }, { 0x0, 6, 0x07, 0, klwpsnaremnn }, { 0, 6, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x02}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &sfehycqllmim };
static const struct kdjigrgqrois ayiandsmqmhm = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, yesurpvnxprn }, { 1, 1, 0x07, 0, gisktbnifqko }, { 1, 0, 0x03, 0, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{2, 9}, 4, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, pqgspokxpjpv, &tuctowhqdgtw };
static const struct kdjigrgqrois zqfofvjkvbgk = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, jfribqhxkcfd }, { 0, 1, 0x07, 0, rhhlairhixpb }, { 0, 2, 0x07, 0, btjmcnhdbjhv }, { 0, 1, 0x08, 3, xaypbuvcjaja }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0xc0}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, babjaboxqjtq, &wsgdrhxlewqi };
static const struct kdjigrgqrois rvjjerpqgvnk = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {40, 136, 0, 0}, { 1, 5, 0x1E, 1, yesurpvnxprn }, { 1, 6, 0x07, 0, lmnidopusvcf }, { 1, 7, 0x0E, 1, pbvggpmjsmwa }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x40}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bspdaeureyvl, &ituhechfmvhy };
static const struct kdjigrgqrois ujyadpeuzixd = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 168, {12, 44, 68, 44}, { 3, 3, 0x0f, 0, yesurpvnxprn }, { 3, 4, 0x07, 0, klwpsnaremnn }, { 3, 3, 0xe0, 5, gljwqnkgvonk }, { 0, 0, 0, 0, NULL }, &mvzwwwhtgarp, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x03}, .tfdvcvkctfsw.jpelfzaadwso = {{3, 9}, 5, 0x03}}, moagfmqignav, &ssbdydnaatik };
static const struct kdjigrgqrois alsmfmtkxbtm = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 170, {12, 44, 70, 44}, { 3, 3, 0x1e, 1, yesurpvnxprn }, { 3, 4, 0x07, 0, klwpsnaremnn }, { 3, 3, 0xe0, 5, gljwqnkgvonk }, { 0, 0, 0, 0, NULL }, &mvzwwwhtgarp, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 5, 0x03}, .tfdvcvkctfsw.jpelfzaadwso = {{3, 9}, 5, 0x03}}, moagfmqignav, &wlqancmfqcej };
static const struct kdjigrgqrois wizokjxixoqe = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 48, {40, 8, 0, 0}, { 0x80, 3, 0x0e, 1, sqjlpwsojbia }, { 0, 2, 0x07, 0, gemltkeahgdn }, { 0, 2, 0x60, 5, rigdugjowjha }, { 1, 0, 0x0f, 0, zkyldkuyylyj }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0x10}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, tsdqbxzeriog, &nnndecoqlrsb };
static const struct kdjigrgqrois stxmttffbqmu = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 72, {8, 64, 0, 0}, { 1, 3, 0x7e, 1, blapmzvtxfpb }, { 1, 1, 0x07, 0, klwpsnaremnn }, { 1, 1, 0x70, 4, faajsjsemavy }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, bspdaeureyvl, &ofimmufgbfjt };
static const struct kdjigrgqrois tdisgnnsqisu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 13, 0x1e, 1, xyulyfqvekqy }, { 0, 6, 0x0f, 0, zsbjpadkqkhk }, { 0, 8, 0x07, 0, mbjbojreykno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 5, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &bvpsdmkepzbc };
static const struct kdjigrgqrois kzjlxrbscuzb = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 0, 0x1e, 1, yesurpvnxprn }, { 0, 1, 0xf0, 4, lgjaumkzwgpi }, { 0, 0, 0x60, 5, uhtggzmnvqwz }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, gjczrrnciugo, &zknvqcxtnhxh };
static const struct kdjigrgqrois gijmxzwsuqvw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1e, 1, qsjskffkkdso }, { 0, 2, 0x0e, 1, ybpyvlaaytbg }, { 0, 1, 0x60, 5, uxfnphantyno }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, &sraexlzzubpr };
static const struct kdjigrgqrois jhrexlqrvkxh = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x1e, 1, qsjskffkkdso }, { 0, 1, 0xc0, 6, rycifytdnudx }, { 0, 1, 0x3f, 0, smiqakoclcjh }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 8}, 2, 0x32}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, &tthkoixletsg };
static const struct kdjigrgqrois efmpyvqefomk = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, yesurpvnxprn }, { 0, 1, 0x07, 0, rhhlairhixpb }, { 0, 2, 0x07, 0, btjmcnhdbjhv }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0xc0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0}, 0, 0}}, wrarviifhafn, &scceroynzfgz };
static const struct kdjigrgqrois dhmftsrelqxk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0e, 1, dayiqypyjymc }, { 0, 0, 0x07, 0, ybpyvlaaytbg}, { 0, 0, 0x30, 4, uxfnphantyno}, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, &mqajuwzrmobl };
static const struct kdjigrgqrois ruqjkexjkmma = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 134, {35,32,35,32}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0, 0, 0x07, 0, uqvgywnmerzv }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, npahjdskfqoc, &tsubxikehlyo };
static const struct kdjigrgqrois vzxfrnazfdok = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 134, {35,32,35,32}, { 0, 1, 0x0f, 0, avvbimutskbi }, { 0, 0, 0x07, 0, uqvgywnmerzv }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, npahjdskfqoc, &acjfdujbczqe };
static const struct kdjigrgqrois vwnghryfofmz = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xe0, 5, mqywnqvipdef }, { 0, 1, 0x07, 0, rhhlairhixpb }, { 0, 2, 0x07, 0, btjmcnhdbjhv }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 1, 0xc0}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0}, 0, 0}}, wrarviifhafn, &lgtnyzkrnwsw };
static const struct kdjigrgqrois kstyqpvxvbtu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 1, 0x7e, 1, nfhmibmlxsnc }, { 0, 4, 0x0e, 1, cebtibulumkf }, { 0, 4, 0x70, 4, rigdugjowjha }, { 0, 5, 0xff, 0, erzagzfqxsce }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 4, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, wpbbehpommlp, &tcozbxwdupxg };
static const struct kdjigrgqrois jvmmmufvqsfm = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 40, {24, 8, 8, 0}, { 1, 0, 0xe0, 5, bjwkqubxshep }, { 0, 1, 0x70, 4, fmxgjfnrbqki }, { 0, 1, 0x03, 0, rigdugjowjha }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0,9},2,0x11}}, xtabulhrwatt, &nqclnibzqbfj };
static const struct kdjigrgqrois iwjufirfknib = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 104, {16, 88, 0, 0}, { 1, 1, 0x7e, 1, nfhmibmlxsnc }, { 1, 2, 0x07, 0, qifhtoqqzsmy }, { 1, 2, 0x38, 3, fqqkwwpykiir }, { 0, 0, 0, 0, NULL }, &mdwgdukekmmi, {.tfdvcvkctfsw.dntwwzvcqjni = {{1, 9}, 2, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, laxvqrktwdxt, &mdtnuewmwfod };
static const struct kdjigrgqrois mmnxfjaxsesw = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0xf0, 4, qsjskffkkdso }, { 0, 3, 0x07, 0, cytfrmrvpryw }, { 0, 2, 0x03, 0, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 2, 0x07}, .tfdvcvkctfsw.jpelfzaadwso = {{0,0},0,0}}, jlledcdowuhe, &zfxcractzbdd };
static const struct kdjigrgqrois mpgpfrgmhnlf = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfc, 2, yesurpvnxprn }, { 3, 5, 0x70, 4, fawtprpzhhee }, { 3, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL }, &eogngwbanwxf, {.tfdvcvkctfsw.dntwwzvcqjni = {{3, 9}, 5, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{3, 9}, 9, 0x0f}}, preizmuhmxgq, &xddxzbwkgxzf };
static const struct kdjigrgqrois mngqtsbtwmrh = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 312, {160, 152, 0, 0}, { 1, 6, 0xfe, 1, gcajfekxbndx }, { 1, 5, 0x70, 4, fawtprpzhhee }, { 1, 8, 0xf0, 4, mscfzyeboixu }, { 0, 0, 0, 0, NULL }, &vuquyzbxithi, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 3}, 6, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{1, 9}, 5, 0x01}}, jlwtbfzaxhsq, &zycyzppwoguf };
static const struct kdjigrgqrois hhyzskglavdj = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 56, {48, 8, 0, 0}, { 0, 1, 0xfe, 1, lgyvrryfcusz }, { 0, 2, 0x0f, 0, fpgevjrrppie }, { 0, 2, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, ktebtmxrsqgx, &tcozbxwdupxg };
static const struct kdjigrgqrois ighvyhufndok = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 67, {35,32,0,0}, { 0, 1, 0x0f, 0, qsjskffkkdso }, { 0, 0, 0x07, 0, seowdspzlhoq }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, aqjqvbpvfzav, &secivibyrhrv };
static const struct kdjigrgqrois uerhareoenfq = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 40, {32,8,0,0}, { 0, 0, 0x0f, 0, yesurpvnxprn }, { 0x40, 1, 0xF0, 4, kdgkzyejcxva }, { 0, 1, 0xF0, 4, rlxcceajnzyl }, { 0, 0, 0, 0, NULL}, &jvwspbdlarsq, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x01}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, wpbbehpommlp, NULL };
static const struct kdjigrgqrois gdajyymfpymp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 68, {68,0,0,0}, { 0, 1, 0x0f, 0, yesurpvnxprn }, { 0, 0, 0x07, 0, klwpsnaremnn }, { 0, 0, 0x30, 4, pxrplmlbjsmu }, { 0, 0, 0, 0, NULL}, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 0, 0x08}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, jlledcdowuhe, NULL };
static const struct kdjigrgqrois jfdpzapzpdbh = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 72, {64,8,0,0}, { 0, 0, 0xF3, 0, ughiiqecuihs }, { 0, 4, 0xf0, 4, pfnnwdjtlbux }, { 0x80, 7, 0x0e, 1, ijcuojfqqiuu }, { 1, 0, 0x03, 0, gmlsdfbubkuc }, &slpynbuhdnel, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 1, 0x04}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, babjaboxqjtq, NULL };
static const struct kdjigrgqrois ixudfderxdpq = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 160, {32,32,32,64}, { 0, 2, 0x0F, 0, yesurpvnxprn }, { 0, 2, 0x70, 4, lrpdggnbestj }, { 2, 0, 0x07, 0, rkpucvzgaotl }, { 0, 0, 0, 0, NULL }, &goppveltigkj, {.tfdvcvkctfsw.dntwwzvcqjni = {{0, 9}, 2, 0x80}, .tfdvcvkctfsw.jpelfzaadwso = {{0, 0}, 0, 0}}, zsgropnvkcoz, NULL };
static const struct kdjigrgqrois* vkxqvtwjwxqf[] = { &qsdwmryagsdi, &vzovultgwxim, &ihtscewywgav, &oijxqsbsbgvq, &qkgefsfjihxs, &otiqxygoiugu, &warcmtzmafxy, &qdiclqzmfprt, &rtqepxcnrkmf, &wtdggcarexgo, &yfqozgtffslp, &snmyfmqgljkf, &obdhwlkevdnh, &nptmjgcficvb, &vxtwgewcbrtn, &jyftkapdkvor, &fxvbogqptosy, &ktckthnotann, &dhszzjqldvoh, &rxxoilsyiquz, &lgjgwbbusaqn, &hlthoqlvqnbw, &comjchmqyjnc, &irtcvayuclqm, &solodyyhvfay, &hsdqkoohntxk, &itojqesnivsv, &wmaugqnzazuz, &jqeejpilbnit, &zsfompibvyaa, &jvtsnrffmodk, &ngunmbuoqatr, &abjcmxxyszoc, &zfxrplzukyty, &vvjoerjojqly, &pamgcdjugiwi, &emskvqsithcx, &smtidvdtqwyk, &lagigftxqlnq, &wlpvcoydygxy, &ssyttfdhmgwj, &vjiakqzshpyz, &vqwkeghjpzim, &rlpdfbqgfyqf, &mobbnelvcdbm, &rndgwlqalsuw, &zusrguarcnzw, &zaxpayyxrtag, &ysbgyajixyxd, &addaktyujmok, &nwxvuxlmrgyt, &aprwhnxdzuoc, &mlwbkjywxiab, &xnlwucyxdqnq, &salvsmnnupvn, &lwmfcjddzyro, &ufxcvttqyigs, &hrocdvrwuugo, &yippqohmxqux, &eohspvxcikix, &sbkqrklncffc, &evnhdkvockig, &grkmijryilwt, &vxzprvcbybmv, &cloexghowbkj, &ufeyduqeesnu, &yzifbmmicbjn, &jyhyyaytglkf, &zmwhyiyarosl, &yhlkknfrvswq, &lbdmjbcijpyv, &dsfnontaqxot, &hbdqlqwxryuw, &nsljayaudxbv, &aiodepttskzw, &vjeofgozldyf, &gwswllrtoojq, &pnnsprfpmekw, &gbbgksgdnkdf, &nowzwkhiingd, &jzdrmsqtjjop, &tgltsveuxqxt, &dfajapsbcutk, &sguwdmkcrbbv, &nocxnnmyrydy, &bxpwzfhptljc, &qvcgxekxpsdm, &vkpemgbncqjj, &kguzzbuvgism, &nbxxqqaadchu, &jitbaxkawwpp, &hltxijiaeuhg, &diiyajjbgcsr, &kxnwuxwabopj, &ywngqafzvspd, &xmyrzlaktydf, &lswvpguisezg, &qvibprkepsky, &ebejwdgxdagz, &pktuqtwsehkd, &stitjlhumoje, &rjtzzvpmwdkl, &auyikmaqkcxc, &bjlumvyqzbno, &egydrbpwupnm, &yjjtbxlfhcdl, &qvwhqkmkxnvf, &ryrxvjdrnlim, &klaivszdgmir, &jorkahsqbkmq, &tgsbcjgjkrvf, &acxcrwvuzqtc, &bapsveqsvjdi, &nhnzfpcujops, &ezggtzgiuaco, &ovmapinlwdgb, &vfwjxjeylucs, &btvmximcaurh, &ohmphjtfdkce, &hzarpdynvehn, &uryvscmqvnnb, &pakgkwlxshpl, &hcolemynvbce, &skegmkgfiyba, &eymsudxnvgvd, &rxyleixlqrwu, &csaoyocpkkyo, &ttsbefnkxwqe, &cxwzbjtsucyg, &umcokjydehoc, &qpjgvfopsgol, &pijmcwegzugw, &rzctmzrxepqt, &fdcarhglohao, &hkkohiwmeyxc, &nfrwzaaytelk, &tdylkejpbort, &ynsqhayeowme, &pwwqgwuefxqu, &fgvqxfqylskx, &mxyyuodkfsvy, &muwbsfibembc, &hsstjljykcsa, &ggqjccroewop, &efofrfvummit, &yagnxlhryawp, &cnmczudfhmky, &dmorhjuzhzos, &khktjforhcvq, &govsbifshdnc, &uakyqzyevrmr, &dcrcclqcvagq, &pgorfewkupiq, &vesysmuzkxrf, &bitbbyjfaxnz, &tdisgnnsqisu, &ozdgmusrqwqs, &rqclwwnempln, &vqobzlpjjiff, &scpyjcnenctw, &gzlvaqltfbus, &gxksjtupqyrv, &hnatmvnzsbmz, &lpspfonofgai, &jwneeevuuinp, &lxnjcnfcwwhh, &riqkjcrfkzyt, &ppxhlrrtomxz, &npsgiuxrmgxw, &ctchgcyohjbz, &ekpqcboxkfft, &titqhveisrjm, &qltdtyyfardt, &zcbhtmxhsuai, &pkcqiuicudrt, &rjtdtifwfddh, &vsyovsemcyqm, &xlmglueffnca, &irjptugwmjkp, &bcgmlxkmltni, &pyylateuqiuz, &ocrddalsncdz, &iwzpqcfsvhhx, &xjwodzreuejn, &yjczyurvkfgs, &fxtbeamwutah, &uiefcghuzoiw, &tczgbnrvjaaa, &fhsiewsdazly, &hbeybynugvlv, &bizqxgqhvkgt, &qknxnqlbujgc, &miiytmxzjqxo, &hnsootgmwvyv, &wqgnclorhdli, &xivdfecolbcb, &rvqaeffvvuyj, &doccpadnzytt, &huvvedhkvclf, &kiudswjbdlso, &vvmheedajore, &ygzugiyaengv, &zspvgsdokutk, &cxpnietqgvia, &bemtzoiriqos, &xjymijmytrye, &xuysuvuuailw, &fqjmiiuskpqc, &kfysfmvcdnin, &vgssvcotncma, &ibsxhdsowrqu, &nktgtfnpxkhn, &jgowmjqvzngf, &ysxdfmkzzeff, &xrgleqhjsmyl, &sjshlmeutilm, &atpdkmjgogzr, &ggzadtlaewgk, &xcquheqwijlx, &bxaqdjefufbv, &jkqfjlqiojkc, &yujlzixtceuy, &nduavsnvorto, &mqwmrkgztcks, &zkcosrhlskoq, &bdfqbuizkmhj, &dptpmwgklgie, &hsklalvkhmxg, &imvenpourfsd, &aeiuewwzfolw, &erytzuscorjo, &pgdjhacaewel, &irmggcdbnyyn, &gpkebkecfcdw, &bktxhdlsrkvv, &gribyoljwnok, &vrflmzrbjtjb, &ftkrobveanxx, &farxtgpfdtkj, &jahotgecgbrb, &ifjvrjjgsvpu, &pzakyjdtwkhp, &nshwimhyqjdg, &kzopmwvqfhif, &audymxwdevcq, &sbfnuegopgkd, &raqywvkfkrda, &hhoulpxmjvom, &dultzplshqsr, &ojzrnifzhdyk, &zcswrvhcligz, &bgbjyjjqivrh, &xdpfxlhmecnq, &djcwzivlgnlx, &etxtpjkzwtzj, &ubyfsginzvsk, &mwnajsafjmcn, &kjqekvbuobix, &maycgrfalbek, &aadrxmlcismv, &qhgblsrwcbmn, &hopmureetzpb, &abuaqrvjafyo, &mevxayilakqy, &yylprirnggpg, &dmsohjyoajbz, &jpwiwimpbenw, &kzmrfqcsuqiv, &hxeqwlkckhpl, &cefhzlctfnnf, &fsisdblgxpaq, &jkuhcgycrevh, &vceccfmcuxuy, &cddiqjejjoaj, &pubqtrkuwbee, &glcbnytvqqjg, &jjssohfwandu, &ogxmlmmyglbz, &lonehgasbcqv, &hkzqbyymzhyv, &wvwqadyowlmq, &vuvoabrglioa, &awadfwojufyt, &hulypnpuywaf, &sdwxcahnlksc, &xzbvqmjcmrzm, &ayiandsmqmhm, &zqfofvjkvbgk, &rvjjerpqgvnk, &nwlnayjhawnw, &ujyadpeuzixd, &wuxcqqkcczul, &alsmfmtkxbtm, &fgnapobjzqqt, &hzfvrhtypamp, &wizokjxixoqe, &stxmttffbqmu, &kzjlxrbscuzb, &gijmxzwsuqvw, &jhrexlqrvkxh, &efmpyvqefomk, &dhmftsrelqxk, &ruqjkexjkmma, &vzxfrnazfdok, &vwnghryfofmz, &kstyqpvxvbtu, &jvmmmufvqsfm, &iwjufirfknib, &mmnxfjaxsesw, &mpgpfrgmhnlf, &mngqtsbtwmrh, &hhyzskglavdj, &ighvyhufndok, &blhbhbjngidd, &gdlxkzwqlgjm, &sswomsklwbzb, &vgofhluexhks, &uerhareoenfq, &gdajyymfpymp, &jfdpzapzpdbh, &ixudfderxdpq,
#ifndef _NO_DEPRECATED
&cciruoeyyuli, &hdqcsbidntks, &vohyjumcigco, &mpbaqkcufixu, &nnawposflmbi, &wcvsnaxbvase,
#endif
};
static const uint16_t ohhfkklvqouy=sizeof(vkxqvtwjwxqf)/sizeof(struct kdjigrgqrois*);
static uint8_t pgxiavlktuhc(const sgqtcddyvqhi* ovxhljuweifs, uint8_t uqxpzbhrcafl, bool bphfxqtjuuqh) { uint8_t tvozhzlazqgz;
uint8_t dqzgbqdrcraf;
uint8_t uuhyurpptnyw = 0;
if (ovxhljuweifs->ovxhljuweifs != NULL) { tvozhzlazqgz = (sxsgupbcixzv[ovxhljuweifs->lxnfhtpgqfci&0x03][ovxhljuweifs->mvclhuiimujy&0x3f]&ovxhljuweifs->lyjelnqjwcpn)>>(ovxhljuweifs->iqvisgvmqmhd&0x07);
dqzgbqdrcraf = ovxhljuweifs->ovxhljuweifs[uqxpzbhrcafl]&(ovxhljuweifs->lyjelnqjwcpn>>(ovxhljuweifs->iqvisgvmqmhd&0x07));
if (ovxhljuweifs->lxnfhtpgqfci&0x20) { const struct aaqxyrxbybvu* abqsycveqkaw = (const struct aaqxyrxbybvu*)(ovxhljuweifs->ovxhljuweifs);
dqzgbqdrcraf = ((const uint8_t*)abqsycveqkaw->yfesjtznxtiz)[uqxpzbhrcafl];
} if (!(ovxhljuweifs->lxnfhtpgqfci & 0x40) || bphfxqtjuuqh) { if (ovxhljuweifs->mvclhuiimujy & 0x80) { uuhyurpptnyw = ((dqzgbqdrcraf&0xf0)-(tvozhzlazqgz&0xf0)) | ((dqzgbqdrcraf-tvozhzlazqgz)&0x0f);
} else if (ovxhljuweifs->mvclhuiimujy & 0x40) { uuhyurpptnyw = ((dqzgbqdrcraf>>4)+(dqzgbqdrcraf&0x0f)) - ((tvozhzlazqgz>>4)+(tvozhzlazqgz&0x0f));
} else { uuhyurpptnyw = dqzgbqdrcraf - tvozhzlazqgz;
} } if (bphfxqtjuuqh) { sxsgupbcixzv[ovxhljuweifs->lxnfhtpgqfci&0x03][ovxhljuweifs->mvclhuiimujy&0x3f] = (sxsgupbcixzv[ovxhljuweifs->lxnfhtpgqfci&0x03][ovxhljuweifs->mvclhuiimujy&0x3f]&(~ovxhljuweifs->lyjelnqjwcpn)) | ((dqzgbqdrcraf<<(ovxhljuweifs->iqvisgvmqmhd&0x07))&ovxhljuweifs->lyjelnqjwcpn);
} } return uuhyurpptnyw;
} static uint8_t ychytxuxyzfe(const sgqtcddyvqhi* ovxhljuweifs, uint8_t uqxpzbhrcafl, bool bphfxqtjuuqh) { uint8_t uuhyurpptnyw = 0;
uint8_t htodnioledof;
const sgqtcddyvqhi* qkdbwsmyxrve;
if (ovxhljuweifs->lxnfhtpgqfci&0x10) { qkdbwsmyxrve = (const sgqtcddyvqhi*)ovxhljuweifs->ovxhljuweifs;
for (htodnioledof=0; htodnioledof<ovxhljuweifs->iqvisgvmqmhd; htodnioledof++)
{ uuhyurpptnyw |= pgxiavlktuhc(&qkdbwsmyxrve[htodnioledof], uqxpzbhrcafl, bphfxqtjuuqh);
} } else { uuhyurpptnyw = pgxiavlktuhc(ovxhljuweifs, uqxpzbhrcafl, bphfxqtjuuqh);
} return uuhyurpptnyw;
} static bool gzhrykjwmzua(const struct kdjigrgqrois* shzveqsbwpgu, bool xmtdckoioaxx) { uint8_t htodnioledof = 0;
algorithm_t wxakirxpmsid;
mqhiridcenhi = NULL;
while (shzveqsbwpgu->afnuksvbkbvr[htodnioledof].zwvhuwtjrnho != NULL) { wxakirxpmsid = shzveqsbwpgu->afnuksvbkbvr[htodnioledof].zwvhuwtjrnho;
if (!wxakirxpmsid(shzveqsbwpgu, shzveqsbwpgu->afnuksvbkbvr[htodnioledof].kgfvcoakbkgf, xmtdckoioaxx)) { return false;
} htodnioledof++;
} return true;
} static bool znsfqzxfwtus(const struct vpdearhvdwqb* tfdvcvkctfsw, bool xmtdckoioaxx) { uint8_t htdeariorzfb;
htdeariorzfb = sxsgupbcixzv[tfdvcvkctfsw->jxctryevobrs.uzajmeiqozpf][tfdvcvkctfsw->mvclhuiimujy];
if (xmtdckoioaxx) { sxsgupbcixzv[tfdvcvkctfsw->jxctryevobrs.uzajmeiqozpf][tfdvcvkctfsw->mvclhuiimujy] = scvmjwhwfhna[tfdvcvkctfsw->jxctryevobrs.yfzeivmnnrai](htdeariorzfb, tfdvcvkctfsw->bits);
return true;
} else { return sxsgupbcixzv[tfdvcvkctfsw->jxctryevobrs.uzajmeiqozpf][tfdvcvkctfsw->mvclhuiimujy] == scvmjwhwfhna[tfdvcvkctfsw->jxctryevobrs.yfzeivmnnrai](htdeariorzfb, tfdvcvkctfsw->bits);
} } static void ruhtuvqddsig(bc7215DataVarPkt_t* vxvmexsmwrru, int8_t klubakdbwntd, uint8_t nmjqlefauvwt) { uint8_t htodnioledof;
int8_t gkblwzvyaito;
bool pjtvtokjehhd=0;
for (htodnioledof=0; htodnioledof<nmjqlefauvwt; htodnioledof++)
{ for (gkblwzvyaito=(vxvmexsmwrru->bitLen+7)/8-1; gkblwzvyaito>=klubakdbwntd; gkblwzvyaito--)
{ if (vxvmexsmwrru->data[gkblwzvyaito] & 0x80) { vxvmexsmwrru->data[gkblwzvyaito] <<= 1;
if (pjtvtokjehhd == 1) { vxvmexsmwrru->data[gkblwzvyaito] |= 0x01;
} pjtvtokjehhd = 1;
} else { vxvmexsmwrru->data[gkblwzvyaito] <<= 1;
if (pjtvtokjehhd == 1) { vxvmexsmwrru->data[gkblwzvyaito] |= 0x01;
} pjtvtokjehhd = 0;
} } } } static void qdutjhgyloxu(bc7215DataVarPkt_t* vxvmexsmwrru, int8_t klubakdbwntd, uint8_t nmjqlefauvwt) { uint8_t htodnioledof;
int8_t gkblwzvyaito;
bool pjtvtokjehhd=0;
for (htodnioledof=0; htodnioledof<nmjqlefauvwt; htodnioledof++)
{ for (gkblwzvyaito=(vxvmexsmwrru->bitLen+7)/8-1; gkblwzvyaito>=klubakdbwntd; gkblwzvyaito--)
{ if (vxvmexsmwrru->data[gkblwzvyaito] & 0x01) { vxvmexsmwrru->data[gkblwzvyaito] >>= 1;
if (pjtvtokjehhd == 1) { vxvmexsmwrru->data[gkblwzvyaito] |= 0x80;
} pjtvtokjehhd = 1;
} else { vxvmexsmwrru->data[gkblwzvyaito] >>= 1;
if (pjtvtokjehhd == 1) { vxvmexsmwrru->data[gkblwzvyaito] |= 0x80;
} pjtvtokjehhd = 0;
} } } } static void hvmacthavfnw(uint8_t jxctryevobrs[][BC7215_MAX_RX_DATA_SIZE], bc7215DataVarPkt_t* vxvmexsmwrru, const struct kdjigrgqrois* shzveqsbwpgu) { uint16_t ahhnhjbkolfz = 0;
uint8_t yatfymuobwig = 0;
uint8_t htodnioledof;
uint8_t emubljrywvpd = 0;
uint8_t tizdudwljawi;
uint8_t afiuuxnrrcmt;
uint16_t qnicjpemhcqz;
qnicjpemhcqz = shzveqsbwpgu->nshlnwwdnxmh[0]+shzveqsbwpgu->nshlnwwdnxmh[1]+shzveqsbwpgu->nshlnwwdnxmh[2]+shzveqsbwpgu->nshlnwwdnxmh[3];
while (ahhnhjbkolfz < qnicjpemhcqz) { tizdudwljawi = emubljrywvpd+(shzveqsbwpgu->nshlnwwdnxmh[yatfymuobwig]+7)/8;
for (htodnioledof=emubljrywvpd; htodnioledof<tizdudwljawi; htodnioledof++)
{ jxctryevobrs[yatfymuobwig][htodnioledof-emubljrywvpd] = vxvmexsmwrru->data[htodnioledof];
} afiuuxnrrcmt = shzveqsbwpgu->nshlnwwdnxmh[yatfymuobwig]%8;
if (afiuuxnrrcmt != 0) { if ((shzveqsbwpgu->signature&0x30) == 0x30) { jxctryevobrs[yatfymuobwig][tizdudwljawi-emubljrywvpd-1] &= gigfcrhtxgdj[afiuuxnrrcmt];
qdutjhgyloxu(vxvmexsmwrru, tizdudwljawi-1, afiuuxnrrcmt);
} else { jxctryevobrs[yatfymuobwig][tizdudwljawi-emubljrywvpd-1] &= aznxoegkdurg[afiuuxnrrcmt];
ruhtuvqddsig(vxvmexsmwrru, tizdudwljawi-1, afiuuxnrrcmt);
} emubljrywvpd = tizdudwljawi-1;
} else { emubljrywvpd = tizdudwljawi;
} ahhnhjbkolfz += shzveqsbwpgu->nshlnwwdnxmh[yatfymuobwig];
yatfymuobwig++;
} } static uint8_t ijzgtrlowffo(uint8_t byte) { return (aatxfupsmyuf[byte & 0x0F] << 4) | aatxfupsmyuf[byte >> 4];
} static uint8_t ryfkuxobvxzc(uint8_t byte) { return (ukdrdbpzsusv[byte >> 4]<<4) | ukdrdbpzsusv[byte & 0x0f];
} static void jicxmagmqots(const struct kdjigrgqrois* shzveqsbwpgu) { uint8_t htodnioledof, gkblwzvyaito;
for (htodnioledof=0; htodnioledof<4; htodnioledof++)
{ for (gkblwzvyaito=0; gkblwzvyaito<(shzveqsbwpgu->nshlnwwdnxmh[htodnioledof]+7)/8; gkblwzvyaito++)
{ sxsgupbcixzv[htodnioledof][gkblwzvyaito] = ijzgtrlowffo(sxsgupbcixzv[htodnioledof][gkblwzvyaito]);
} } } static void iwsmbpihijwx(const struct kdjigrgqrois* shzveqsbwpgu) { uint8_t htodnioledof, gkblwzvyaito;
for (htodnioledof=0; htodnioledof<4; htodnioledof++)
{ for (gkblwzvyaito=0; gkblwzvyaito<(shzveqsbwpgu->nshlnwwdnxmh[htodnioledof]+7)/8; gkblwzvyaito++)
{ sxsgupbcixzv[htodnioledof][gkblwzvyaito] = ryfkuxobvxzc(sxsgupbcixzv[htodnioledof][gkblwzvyaito]);
} } } static bool mlauusswuxrq(const struct kdjigrgqrois* shzveqsbwpgu) { uint8_t frknqavyrorl;
if (fpecgvzrimrg) { if (eshuyivywcyl->cjxibzuelnnx != NULL) { frknqavyrorl = eshuyivywcyl->cjxibzuelnnx->aejqufrcwkkq[vbhticufdmxg-60];
} else { frknqavyrorl = gculcshoavsy.aejqufrcwkkq[vbhticufdmxg-60];
} } else { frknqavyrorl = hxeevvisyxvd-16;
} if (pgxiavlktuhc(&shzveqsbwpgu->dehqyzmoyahd, frknqavyrorl, dblsytetyfke) != 0) { return false;
} if (pgxiavlktuhc(&shzveqsbwpgu->fgstngnlzpzg, MODE_COOL, dblsytetyfke) != 0) { return false;
} return gzhrykjwmzua(shzveqsbwpgu, dblsytetyfke);
} static int8_t dyziyowpoeky(const sgqtcddyvqhi* ovxhljuweifs, int8_t hcxgfinjxmsa) { sgqtcddyvqhi ivihlgtqdsuh = *ovxhljuweifs;
int8_t htodnioledof;
ivihlgtqdsuh.lxnfhtpgqfci &= 0x3F;
htodnioledof = hcxgfinjxmsa/2;
while (htodnioledof >= 0) { if (pgxiavlktuhc(&ivihlgtqdsuh, htodnioledof, dblsytetyfke) == 0) { return htodnioledof;
} htodnioledof--;
} for (htodnioledof=hcxgfinjxmsa/2+1; htodnioledof<hcxgfinjxmsa; htodnioledof++)
{ if (pgxiavlktuhc(&ivihlgtqdsuh, htodnioledof, dblsytetyfke) == 0) { return htodnioledof;
} } return -1;
} static int8_t zevjgzewucqn(const struct yibohltnjvlz* nmortizzxrfj) { int8_t htodnioledof;
int8_t ntcllndfinew, phfgwckkkbev;
int8_t baslfwtcahwv = -1;
sgqtcddyvqhi ivihlgtqdsuh = eshuyivywcyl->dehqyzmoyahd;
ivihlgtqdsuh.lxnfhtpgqfci &= 0x3f;
for (htodnioledof=0; htodnioledof<15; htodnioledof++)
{ ntcllndfinew = 14-htodnioledof;
phfgwckkkbev = 15+htodnioledof;
if (pgxiavlktuhc(&ivihlgtqdsuh, nmortizzxrfj->aejqufrcwkkq[ntcllndfinew], dblsytetyfke) == 0) { baslfwtcahwv = ntcllndfinew;
if (nmortizzxrfj->xlfohizjsfwi.ovxhljuweifs != NULL ) { if (ychytxuxyzfe(&nmortizzxrfj->xlfohizjsfwi, ntcllndfinew, dblsytetyfke) == 0) { return baslfwtcahwv;
} } } if ((phfgwckkkbev<=28) && (pgxiavlktuhc(&ivihlgtqdsuh, nmortizzxrfj->aejqufrcwkkq[phfgwckkkbev], dblsytetyfke) == 0)) { baslfwtcahwv = phfgwckkkbev;
if (nmortizzxrfj->xlfohizjsfwi.ovxhljuweifs != NULL ) { if (ychytxuxyzfe(&nmortizzxrfj->xlfohizjsfwi, phfgwckkkbev, dblsytetyfke) == 0) { return baslfwtcahwv;
} } } } return baslfwtcahwv;
} static int8_t pgbtxrtfvzpc(const struct kdjigrgqrois* shzveqsbwpgu) { int8_t yiqmcmksqjww;
uint16_t	zplfbtnkkrtf=0;
const bc7215DataVarPkt_t*	lsmrwsakfmem;
yiqmcmksqjww = 1;
if (!shzveqsbwpgu->spec.uwhisdczmgip) { if ((shzveqsbwpgu->bgofcjmacpch.ovxhljuweifs != NULL) && (shzveqsbwpgu->bgofcjmacpch.ovxhljuweifs[0] != shzveqsbwpgu->bgofcjmacpch.ovxhljuweifs[4]) && !((shzveqsbwpgu->dehqyzmoyahd.lxnfhtpgqfci&0x80) || (shzveqsbwpgu->fgstngnlzpzg.lxnfhtpgqfci&0x80) || (shzveqsbwpgu->kheyzdjrjuew.lxnfhtpgqfci&0x80))) { if (pgxiavlktuhc(&shzveqsbwpgu->bgofcjmacpch, 4, dblsytetyfke) == 0) { if (shzveqsbwpgu->bgofcjmacpch.ovxhljuweifs[4] == shzveqsbwpgu->bgofcjmacpch.ovxhljuweifs[5]) { yiqmcmksqjww = 2;
} else { yiqmcmksqjww = 0;
return yiqmcmksqjww;
} } } if ( !( (eshuyivywcyl->vdjdiohbbbln.tfdvcvkctfsw.dntwwzvcqjni.jxctryevobrs.yfzeivmnnrai == 0) && (eshuyivywcyl->vdjdiohbbbln.tfdvcvkctfsw.dntwwzvcqjni.bits == 0) && (eshuyivywcyl->vdjdiohbbbln.tfdvcvkctfsw.jpelfzaadwso.jxctryevobrs.yfzeivmnnrai == 0) && (eshuyivywcyl->vdjdiohbbbln.tfdvcvkctfsw.jpelfzaadwso.bits == 0) ) ) { if (!wqvxbiaheaem) { if ( znsfqzxfwtus(&eshuyivywcyl->vdjdiohbbbln.tfdvcvkctfsw.dntwwzvcqjni, dblsytetyfke) && znsfqzxfwtus(&eshuyivywcyl->vdjdiohbbbln.tfdvcvkctfsw.jpelfzaadwso, dblsytetyfke) ) { yiqmcmksqjww = 0;
} else if (yiqmcmksqjww == 2) { yiqmcmksqjww = 1;
} } if (shzveqsbwpgu->spec.lrobawqzqmff) { if (yiqmcmksqjww == 1) { yiqmcmksqjww = -1;
} else { yiqmcmksqjww = 2;
} } } } else { lsmrwsakfmem = bc7215_ac_off();
if (lsmrwsakfmem != NULL) { if (lsmrwsakfmem->bitLen != 0) { zplfbtnkkrtf = lsmrwsakfmem->bitLen;
} else { zplfbtnkkrtf = ((const bc7215CombinedMsg_t*)lsmrwsakfmem)->body.msg.datPkt->bitLen;
} } if ((zplfbtnkkrtf == shzveqsbwpgu->bitLen) && lcvfbnqxzxid((bc7215DataVarPkt_t*)&vyudfzxzxuqv)) { if (shzveqsbwpgu->spec.lrobawqzqmff) { yiqmcmksqjww = 2;
} else { yiqmcmksqjww = 0;
} } } return yiqmcmksqjww;
} static uint8_t lrnnkatxtlag(uint8_t vxvmexsmwrru, uint8_t bits, uint8_t* tjtywcjarsmf) { uint8_t byte;
if ((bits != 8) && (bits != 0)) { byte = vxvmexsmwrru&gigfcrhtxgdj[bits];
vxvmexsmwrru >>= bits;
vxvmexsmwrru |= (*tjtywcjarsmf<<(8-bits));
*tjtywcjarsmf = byte;
} return vxvmexsmwrru;
} static uint8_t imwocmpjysre(uint8_t vxvmexsmwrru, uint8_t bits, uint8_t* tjtywcjarsmf) { uint8_t byte;
if ((bits != 8) && (bits != 0)) { byte = vxvmexsmwrru&aznxoegkdurg[bits];
vxvmexsmwrru <<= bits;
vxvmexsmwrru |= (*tjtywcjarsmf>>(8-bits));
*tjtywcjarsmf = byte;
} return vxvmexsmwrru;
} static void cycwqtmggord(const struct kdjigrgqrois* shzveqsbwpgu) { uint8_t lxnfhtpgqfci;
uint16_t gkblwzvyaito;
uint8_t yqvfzpiiscgq = 0;
uint16_t exvqphvfkvmx = 0;
uint8_t sadtyawnxhwl = 0;
uint8_t hbepupjixljo = 0;
uint8_t nmjqlefauvwt = 0;
uint8_t aqxemozlgice;
qlavfhidhmdq.bitLen = shzveqsbwpgu->bitLen;
for (lxnfhtpgqfci = 0; lxnfhtpgqfci < 4; lxnfhtpgqfci++) {
if (shzveqsbwpgu->nshlnwwdnxmh[lxnfhtpgqfci] != 0) { for (gkblwzvyaito = 0; gkblwzvyaito < (shzveqsbwpgu->nshlnwwdnxmh[lxnfhtpgqfci]-nmjqlefauvwt+7)/8; gkblwzvyaito++) {
sadtyawnxhwl = nvhiozlktdhn[lxnfhtpgqfci][gkblwzvyaito+1];
if ((shzveqsbwpgu->signature&0x30) == 0x30) { qlavfhidhmdq.data[yqvfzpiiscgq] = lrnnkatxtlag(nvhiozlktdhn[lxnfhtpgqfci][gkblwzvyaito], nmjqlefauvwt, &sadtyawnxhwl);
} else { qlavfhidhmdq.data[yqvfzpiiscgq] = imwocmpjysre(nvhiozlktdhn[lxnfhtpgqfci][gkblwzvyaito], nmjqlefauvwt, &sadtyawnxhwl);
} yqvfzpiiscgq++;
} exvqphvfkvmx += shzveqsbwpgu->nshlnwwdnxmh[lxnfhtpgqfci];
hbepupjixljo = exvqphvfkvmx%8;
nmjqlefauvwt = (8-hbepupjixljo)&0x07;
if ((nmjqlefauvwt != 0) && (lxnfhtpgqfci != 3) && (shzveqsbwpgu->nshlnwwdnxmh[lxnfhtpgqfci+1] != 0)){ if ((shzveqsbwpgu->signature&0x30) == 0x30) { qlavfhidhmdq.data[yqvfzpiiscgq-1] = (qlavfhidhmdq.data[yqvfzpiiscgq-1]&gigfcrhtxgdj[hbepupjixljo]) | (nvhiozlktdhn[lxnfhtpgqfci+1][0] << hbepupjixljo);
} else { qlavfhidhmdq.data[yqvfzpiiscgq-1] = (qlavfhidhmdq.data[yqvfzpiiscgq-1]&aznxoegkdurg[hbepupjixljo]) | (nvhiozlktdhn[lxnfhtpgqfci+1][0] >> hbepupjixljo);
} } } } if (shzveqsbwpgu->spec.puvjpxepuxnx && shzveqsbwpgu->spec.lkpnrrvrqsdm) { memcpy(zloiimuniybf.data, qlavfhidhmdq.data, (qlavfhidhmdq.bitLen+7)/8);
memcpy(qlavfhidhmdq.data, vyudfzxzxuqv.data, (qlavfhidhmdq.bitLen+7)/8);
exvqphvfkvmx = 0;
for (gkblwzvyaito=0; gkblwzvyaito<qlavfhidhmdq.bitLen/2; gkblwzvyaito++)
{ yqvfzpiiscgq = gkblwzvyaito/4;
aqxemozlgice = qlavfhidhmdq.data[yqvfzpiiscgq] & bmjzspwldmxy[gkblwzvyaito%4];
if ((aqxemozlgice & 0xaa) == 0) { if (zloiimuniybf.data[exvqphvfkvmx/8] & kdcrfwgoywrj[exvqphvfkvmx%8]) { qlavfhidhmdq.data[yqvfzpiiscgq] = (qlavfhidhmdq.data[yqvfzpiiscgq]&(~bmjzspwldmxy[gkblwzvyaito%4])) | (0x55 & bmjzspwldmxy[gkblwzvyaito%4]);
} else { qlavfhidhmdq.data[yqvfzpiiscgq] = qlavfhidhmdq.data[yqvfzpiiscgq] & (~bmjzspwldmxy[gkblwzvyaito%4]);
} exvqphvfkvmx++;
} } } } static void xfzwmuwzhapt(const struct kdjigrgqrois* shzveqsbwpgu, uint8_t gkiurtlomibv, const bc7215DataVarPkt_t* vxvmexsmwrru) { uint8_t bnvferxhyhpp;
uint8_t gkblwzvyaito, k;
uint16_t exvqphvfkvmx;
uint8_t aqxemozlgice;
exvqphvfkvmx = 0;
zloiimuniybf.bitLen = vxvmexsmwrru->bitLen;
bnvferxhyhpp = (vxvmexsmwrru->bitLen+7)/8;
for (gkblwzvyaito=0; gkblwzvyaito<bnvferxhyhpp; gkblwzvyaito++) {
if (shzveqsbwpgu->spec.puvjpxepuxnx && shzveqsbwpgu->spec.lkpnrrvrqsdm) { for (k= 0; k < 4; k++) {
aqxemozlgice = vxvmexsmwrru->data[gkblwzvyaito] & bmjzspwldmxy[k];
if ((aqxemozlgice & 0xaa) == 0) { if ((aqxemozlgice & 0x55) == 0) { zloiimuniybf.data[exvqphvfkvmx/8] &= ~kdcrfwgoywrj[exvqphvfkvmx%8];
} else { zloiimuniybf.data[exvqphvfkvmx/8] |= kdcrfwgoywrj[exvqphvfkvmx%8];
} exvqphvfkvmx++;
} } } else if (gkiurtlomibv&0x40) { zloiimuniybf.data[gkblwzvyaito] = ~vxvmexsmwrru->data[gkblwzvyaito];
} else { zloiimuniybf.data[gkblwzvyaito] = vxvmexsmwrru->data[gkblwzvyaito];
} } hdewbzptlbih(shzveqsbwpgu, (bc7215DataVarPkt_t*)&zloiimuniybf);
} static void hdewbzptlbih(const struct kdjigrgqrois* shzveqsbwpgu, bc7215DataVarPkt_t* vxvmexsmwrru) { hvmacthavfnw(sxsgupbcixzv, vxvmexsmwrru, shzveqsbwpgu);
if (shzveqsbwpgu->spec.ahtyzigcwkfz) { jicxmagmqots(shzveqsbwpgu);
} if (shzveqsbwpgu->spec.puvjpxepuxnx && !shzveqsbwpgu->spec.lkpnrrvrqsdm) { iwsmbpihijwx(shzveqsbwpgu);
} } static void fefldogauyki(const struct kdjigrgqrois* shzveqsbwpgu) { uint8_t htodnioledof, gkblwzvyaito;
uint8_t hsrgsachusdq;
uint8_t bnvferxhyhpp;
for (htodnioledof=0; htodnioledof<4; htodnioledof++)
{ bnvferxhyhpp = (shzveqsbwpgu->nshlnwwdnxmh[htodnioledof]+7)/8;
for (gkblwzvyaito=0; gkblwzvyaito<bnvferxhyhpp; gkblwzvyaito++)
{ hsrgsachusdq = sxsgupbcixzv[htodnioledof][gkblwzvyaito];
if (shzveqsbwpgu->spec.puvjpxepuxnx && !shzveqsbwpgu->spec.lkpnrrvrqsdm) { hsrgsachusdq = ryfkuxobvxzc(hsrgsachusdq);
} if (shzveqsbwpgu->spec.ahtyzigcwkfz) { hsrgsachusdq = ijzgtrlowffo(hsrgsachusdq);
} if (qobvowrftgaq & 0x40) { hsrgsachusdq = ~hsrgsachusdq;
} nvhiozlktdhn[htodnioledof][gkblwzvyaito] = hsrgsachusdq;
} } } static void vwvzidbltkov(const struct odxfhxsrevig* kgfvcoakbkgf) { uint8_t lotscilifaat;
uint8_t uuhyurpptnyw;
uint8_t yiqmcmksqjww;
uint8_t odhazyjtfxnx;
odhazyjtfxnx = kgfvcoakbkgf->odhazyjtfxnx&0x03;
lotscilifaat = sxsgupbcixzv[odhazyjtfxnx][kgfvcoakbkgf->uegiyqtqayhs];
uuhyurpptnyw = (wvephcqvrhxl[kgfvcoakbkgf->ncudadtiieiw]&kgfvcoakbkgf->hvqubynhawbz)<<kgfvcoakbkgf->kjdtvsdspmqy;
yiqmcmksqjww = scvmjwhwfhna[kgfvcoakbkgf->yfzeivmnnrai.yfzeivmnnrai](lotscilifaat, uuhyurpptnyw);
lotscilifaat = (lotscilifaat&(~kgfvcoakbkgf->qpvvigyfqwqu)) | (yiqmcmksqjww&kgfvcoakbkgf->qpvvigyfqwqu);
sxsgupbcixzv[odhazyjtfxnx][kgfvcoakbkgf->uegiyqtqayhs] = lotscilifaat;
}
#ifndef _NO_DEPRECATED
static void abrjhoczimks(void) { bzvflvgyviul = jadyfbnomgtt;
vfjfcbtuqghr = vyudfzxzxuqv;
}
#endif
static void gnefjgqgcnln(void) { jadyfbnomgtt = bzvflvgyviul;
vyudfzxzxuqv = vfjfcbtuqghr;
} static bool aqnomkulnvqa(uint16_t gynflqwznyzf) { eshuyivywcyl = vkxqvtwjwxqf[gynflqwznyzf];
yvufzzwbxjjd = false;
if (((qobvowrftgaq&0xbf) == eshuyivywcyl->signature) && (vyudfzxzxuqv.bitLen == eshuyivywcyl->bitLen)) { xfzwmuwzhapt(eshuyivywcyl, qobvowrftgaq, (const bc7215DataVarPkt_t*)&vyudfzxzxuqv);
if (mlauusswuxrq(eshuyivywcyl)) { if (eshuyivywcyl->fgstngnlzpzg.lxnfhtpgqfci&0x20) { ((const struct aaqxyrxbybvu*)eshuyivywcyl->fgstngnlzpzg.ovxhljuweifs)->shzveqsbwpgu.vdjdiohbbbln.gvgpztzhmfxl(NULL, NULL);
} return true;
} } return false;
} static bool ygnhmdaixvgc(bc7215FormatPkt_t* format, uint16_t qblufafmuhil, uint8_t pvxhudwfwylc, uint8_t nnrzkzuvzcbl) { uint8_t htodnioledof, gkblwzvyaito, oldSpecial, newSpecial, oldTypeCnt;
uint16_t loqwjyrvzuqz;
uint8_t*  tpatyjqdrpme;
uint8_t*  xoqllnokajyy;
if ((format == NULL) || (qblufafmuhil*pvxhudwfwylc > BC7215_MAX_RX_DATA_SIZE*8) || (qblufafmuhil == 0) || (pvxhudwfwylc > 4)) { return false;
} tpatyjqdrpme = (uint8_t*)format;
oldSpecial = (*tpatyjqdrpme&0x07)^0x05;
newSpecial =  oldSpecial*(pvxhudwfwylc+1)+pvxhudwfwylc;
if (newSpecial >8) { return false;
} *tpatyjqdrpme = (*tpatyjqdrpme&0xf8)+(newSpecial^5);
tpatyjqdrpme += 9;
oldTypeCnt = *tpatyjqdrpme;
*tpatyjqdrpme++ = (((oldTypeCnt^0x1d)&0x7f)+1)^29;
*tpatyjqdrpme = (*tpatyjqdrpme&0x80)+(newSpecial^29);
tpatyjqdrpme++;
if ((oldTypeCnt&0x7f) == 29) { *tpatyjqdrpme++ = ((*((uint8_t*)format+1)^29)/2)^29;
*tpatyjqdrpme = 226;
} else { tpatyjqdrpme = tpatyjqdrpme+2*(oldTypeCnt^29);
*(tpatyjqdrpme++) = ((*((uint8_t*)format+1)^29)+1)/2;
*tpatyjqdrpme = 0xff;
} xoqllnokajyy = (uint8_t*)format+17;
tpatyjqdrpme = xoqllnokajyy+oldSpecial*2;
for (gkblwzvyaito=0; gkblwzvyaito<pvxhudwfwylc; gkblwzvyaito++)
{ loqwjyrvzuqz = ((qblufafmuhil*(gkblwzvyaito+1)) |((oldTypeCnt^0x1d)<<12))|0x8000;
*tpatyjqdrpme++ = loqwjyrvzuqz&0xff;
*tpatyjqdrpme++ = loqwjyrvzuqz>>8;
for (htodnioledof=0; htodnioledof<oldSpecial; htodnioledof++)
{ newSpecial = *(xoqllnokajyy+htodnioledof*2);
oldTypeCnt = *(xoqllnokajyy+htodnioledof*2+1);
loqwjyrvzuqz = (qblufafmuhil*(gkblwzvyaito+1)+ (newSpecial | ((oldTypeCnt<<8)&0x0fff))) | ((oldTypeCnt<<8)&0xf000);
*tpatyjqdrpme++ = loqwjyrvzuqz&0xff;
*tpatyjqdrpme++ = loqwjyrvzuqz>>8;
} } if (newSpecial < 8) { *((uint8_t*)format+31) = nnrzkzuvzcbl;
} return true;
}
#ifndef _NO_DEPRECATED
static void kfddmbndyzoa(const struct kdjigrgqrois* shzveqsbwpgu) { const struct icejugalibdt*  vlwwhcpxwopu;
yvufzzwbxjjd = true;
abrjhoczimks();
vlwwhcpxwopu = (const struct icejugalibdt*)shzveqsbwpgu->uuipfhjicnzd->set.vrdfzsmcauwh;
ygnhmdaixvgc(&jadyfbnomgtt, vyudfzxzxuqv.bitLen, vlwwhcpxwopu->pvxhudwfwylc, vlwwhcpxwopu->nnrzkzuvzcbl);
gzhrykjwmzua(vlwwhcpxwopu->shzveqsbwpgu, scdmdvhoqlof);
fefldogauyki(vlwwhcpxwopu->shzveqsbwpgu);
cycwqtmggord(vlwwhcpxwopu->shzveqsbwpgu);
eshuyivywcyl = vlwwhcpxwopu->shzveqsbwpgu;
qobvowrftgaq = jadyfbnomgtt.signature.bits.sig;
bc7215_ac_replace_base(qobvowrftgaq, (const bc7215DataVarPkt_t*)&qlavfhidhmdq);
}
#endif
static bool dsriykjjfaau(uint16_t rbtifqxeabwm, uint8_t ncudadtiieiw, uint8_t ciizngkwhhkv) { ncudadtiieiw &= 0x3f;
if (ciizngkwhhkv == 0) { ciizngkwhhkv = 60;
} if (ciizngkwhhkv < 37) { ciizngkwhhkv = 37;
} if (ciizngkwhhkv > 72) { ciizngkwhhkv = 72;
} ciizngkwhhkv = (ciizngkwhhkv*7)&0xff;
if ((ncudadtiieiw > 1) && (ncudadtiieiw <= 4)) { if (ygnhmdaixvgc(&jadyfbnomgtt, rbtifqxeabwm, ncudadtiieiw-1, ciizngkwhhkv)) { return true;
} } return false;
} static bool pizpnixvzdav(uint8_t bpxhmqiavjwe, const bc7215CombinedMsg_t gjarldacwgah[]) { uint8_t htodnioledof, bnvferxhyhpp;
uint16_t chjejyxefjwi;
struct kdjigrgqrois inkoncmbsghk;
chjejyxefjwi = 0;
bpxhmqiavjwe &= 0x3f;
if ((bpxhmqiavjwe > 0) && (bpxhmqiavjwe <= 4)) { for (htodnioledof=0; htodnioledof<4; htodnioledof++)
{ if ((htodnioledof < bpxhmqiavjwe) && (gjarldacwgah[htodnioledof].body.msg.datPkt != NULL) && (gjarldacwgah[htodnioledof].body.msg.datPkt->bitLen < BC7215_MAX_RX_DATA_SIZE*8)) { inkoncmbsghk.nshlnwwdnxmh[htodnioledof] = gjarldacwgah[htodnioledof].body.msg.datPkt->bitLen;
chjejyxefjwi += inkoncmbsghk.nshlnwwdnxmh[htodnioledof];
if (chjejyxefjwi > BC7215_MAX_RX_DATA_SIZE*8) { return false;
} bnvferxhyhpp = (inkoncmbsghk.nshlnwwdnxmh[htodnioledof]+7)/8;
memcpy(nvhiozlktdhn[htodnioledof], gjarldacwgah[htodnioledof].body.msg.datPkt->data, bnvferxhyhpp);
} else { inkoncmbsghk.nshlnwwdnxmh[htodnioledof] = 0;
} } inkoncmbsghk.bitLen = chjejyxefjwi;
inkoncmbsghk.signature = jadyfbnomgtt.signature.bits.sig;
inkoncmbsghk.spec.puvjpxepuxnx = 0;
cycwqtmggord(&inkoncmbsghk);
return true;
} return false;
} static void odvdnwwbnbcv(const struct kdjigrgqrois* shzveqsbwpgu) { const lygcleobgeet* ajkrsdmojyrq;
#ifndef _NO_DEPRECATED
if (shzveqsbwpgu->bgofcjmacpch.lxnfhtpgqfci&0x80) { ajkrsdmojyrq = ((const struct icejugalibdt*)shzveqsbwpgu->uuipfhjicnzd->set.vrdfzsmcauwh)->yfesjtznxtiz;
} else { ajkrsdmojyrq = shzveqsbwpgu->uuipfhjicnzd->set.vrdfzsmcauwh;
}
#else
ajkrsdmojyrq = shzveqsbwpgu->uuipfhjicnzd->set.vrdfzsmcauwh;
#endif
while ((ajkrsdmojyrq != NULL) && (ajkrsdmojyrq->ulllwrirovmo != NULL)) { if ((ragsgmpbksry[ajkrsdmojyrq->oesqxabczxwe] >= 0) && (ragsgmpbksry[ajkrsdmojyrq->oesqxabczxwe] < 0x0f)) { sxsgupbcixzv[ajkrsdmojyrq->lxnfhtpgqfci][ajkrsdmojyrq->mvclhuiimujy&0x3f] = (sxsgupbcixzv[ajkrsdmojyrq->lxnfhtpgqfci][ajkrsdmojyrq->mvclhuiimujy&0x3f]&(~ajkrsdmojyrq->lyjelnqjwcpn)) | (ajkrsdmojyrq->ulllwrirovmo[ragsgmpbksry[ajkrsdmojyrq->oesqxabczxwe]]&ajkrsdmojyrq->lyjelnqjwcpn);
} ajkrsdmojyrq++;
} } static const bc7215DataVarPkt_t* jtqzfrhqsowa(uint8_t zqcmzpfighmh) { xfzwmuwzhapt(eshuyivywcyl, qobvowrftgaq, (const bc7215DataVarPkt_t*)&vyudfzxzxuqv);
if ((zqcmzpfighmh == 4) || eshuyivywcyl->spec.lrobawqzqmff) { znsfqzxfwtus(&eshuyivywcyl->vdjdiohbbbln.tfdvcvkctfsw.dntwwzvcqjni, scdmdvhoqlof);
znsfqzxfwtus(&eshuyivywcyl->vdjdiohbbbln.tfdvcvkctfsw.jpelfzaadwso, scdmdvhoqlof);
} wvephcqvrhxl[0] = 0;
wvephcqvrhxl[1] = 0;
wvephcqvrhxl[2] = 0;
wvephcqvrhxl[3] = pgxiavlktuhc(&eshuyivywcyl->bgofcjmacpch, zqcmzpfighmh, scdmdvhoqlof);
ragsgmpbksry[0] = -1;
ragsgmpbksry[1] = -1;
ragsgmpbksry[2] = -1;
ragsgmpbksry[3] = zqcmzpfighmh;
odvdnwwbnbcv(eshuyivywcyl);
gzhrykjwmzua(eshuyivywcyl, scdmdvhoqlof);
fefldogauyki(eshuyivywcyl);
cycwqtmggord(eshuyivywcyl);
xfzwmuwzhapt(eshuyivywcyl, qobvowrftgaq, (const bc7215DataVarPkt_t*)&vyudfzxzxuqv);
if (yvufzzwbxjjd) { xlvdqneiksch.body.msg.fmt = &jadyfbnomgtt;
xlvdqneiksch.body.msg.datPkt = (bc7215DataVarPkt_t*)&qlavfhidhmdq;
return (const bc7215DataVarPkt_t*)&xlvdqneiksch;
} else { return (const bc7215DataVarPkt_t*)&qlavfhidhmdq;
} } static void eskpjhgjdyyb(uint8_t vbfnkcenyvzz, uint8_t pvnifltdrgmh) { uint8_t kvsvkxuvfwvy;
uint8_t yrsespxrfjlq;
uint8_t ovxhljuweifs;
kvsvkxuvfwvy = vbfnkcenyvzz >> 4 ;
yrsespxrfjlq = pvnifltdrgmh >> 4 ;
ovxhljuweifs = pvnifltdrgmh&0x0f;
if (yrsespxrfjlq & 0xFC) { yrsespxrfjlq &= 0x03;
ovxhljuweifs += 0x10;
} if ((kvsvkxuvfwvy < 4) && (yrsespxrfjlq < 4)) { if (ragsgmpbksry[kvsvkxuvfwvy] == (vbfnkcenyvzz&0x0f)) { ragsgmpbksry[yrsespxrfjlq] = ovxhljuweifs;
} } else if ((kvsvkxuvfwvy < 8) && (yrsespxrfjlq < 4)) { kvsvkxuvfwvy -= 4;
if (ragsgmpbksry[kvsvkxuvfwvy] < (vbfnkcenyvzz&0x0f)) { ragsgmpbksry[yrsespxrfjlq] = ovxhljuweifs;
} } else if ((kvsvkxuvfwvy < 12) && (yrsespxrfjlq < 4)) { kvsvkxuvfwvy -= 8;
if (ragsgmpbksry[kvsvkxuvfwvy] > (vbfnkcenyvzz&0x0f)) { ragsgmpbksry[yrsespxrfjlq] = ovxhljuweifs;
} } } static bool owdzeookpdkt(uint8_t gkiurtlomibv, const bc7215DataVarPkt_t* dataPktCool25C) { uint16_t htodnioledof;
uint16_t bnvferxhyhpp;
const bc7215FormatPkt_t* fmt = NULL;
eshuyivywcyl = NULL;
ekvawgrcfycz = false;
uohaukzjobju = false;
if ((dataPktCool25C != NULL) && !(gkiurtlomibv&0x80)) { if (dataPktCool25C->bitLen == 0) { fmt = ((const bc7215CombinedMsg_t*)dataPktCool25C)->body.msg.fmt;
if (fmt != NULL) { jadyfbnomgtt = *fmt;
ekvawgrcfycz = true;
} dataPktCool25C = ((const bc7215CombinedMsg_t*)dataPktCool25C)->body.msg.datPkt;
if ((fmt == NULL) || (dataPktCool25C == NULL)) { return false;
} } if ((dataPktCool25C->bitLen <= BC7215_MAX_RX_DATA_SIZE*8) && (dataPktCool25C->bitLen > 0)) { qobvowrftgaq = gkiurtlomibv;
vyudfzxzxuqv.bitLen = dataPktCool25C->bitLen;
bnvferxhyhpp = (vyudfzxzxuqv.bitLen+7)/8;
memcpy(vyudfzxzxuqv.data, dataPktCool25C->data, bnvferxhyhpp);
tvpnkcpbdlod = -1;
for (htodnioledof=0; htodnioledof<ohhfkklvqouy; htodnioledof++) {
if (aqnomkulnvqa(htodnioledof)) { tvpnkcpbdlod = htodnioledof;
wqvxbiaheaem = false;
if ( !eshuyivywcyl->spec.uwhisdczmgip && znsfqzxfwtus(&eshuyivywcyl->vdjdiohbbbln.tfdvcvkctfsw.dntwwzvcqjni, dblsytetyfke) && znsfqzxfwtus(&eshuyivywcyl->vdjdiohbbbln.tfdvcvkctfsw.jpelfzaadwso, dblsytetyfke) ) { wqvxbiaheaem = true;
} return true;
} } } } return false;
} static bool akedehgcckgm(uint8_t bpxhmqiavjwe, const bc7215CombinedMsg_t gjarldacwgah[], uint8_t oqmimngcikpd) { uint8_t hlszevrrbqri;
eshuyivywcyl = NULL;
if ((bpxhmqiavjwe > 0) && ((bpxhmqiavjwe&0x3f) <= 4) && (gjarldacwgah != NULL) && (gjarldacwgah[0].body.msg.fmt != NULL)) { jadyfbnomgtt = *gjarldacwgah[0].body.msg.fmt;
if (dsriykjjfaau(gjarldacwgah[0].body.msg.datPkt->bitLen, bpxhmqiavjwe&0x3f, oqmimngcikpd) && pizpnixvzdav(bpxhmqiavjwe&0x3f, gjarldacwgah)) { hlszevrrbqri = jadyfbnomgtt.signature.bits.sig | (bpxhmqiavjwe&0x40);
return owdzeookpdkt(hlszevrrbqri, (const bc7215DataVarPkt_t*)&qlavfhidhmdq);
} } return false;
} static const bc7215DataVarPkt_t* glucnmhzseje(int8_t hdwyeyojigbv, int8_t qzlsegpdwvuy, int8_t wuhswjqeidrw, int8_t vlwwhcpxwopu) { bool bvjhgvfeltum;
uint8_t zzttduzmzbrv;
uint8_t xkfkkucbfrcx;
const struct kdjigrgqrois* untfwblhfxve;
bvjhgvfeltum = false;
untfwblhfxve = eshuyivywcyl;
if ((vlwwhcpxwopu == KEY_MODE) && (eshuyivywcyl->fgstngnlzpzg.lxnfhtpgqfci&0x20)) { eshuyivywcyl = &((const struct aaqxyrxbybvu*)eshuyivywcyl->fgstngnlzpzg.ovxhljuweifs)->shzveqsbwpgu;
bvjhgvfeltum = true;
} else if (((vlwwhcpxwopu == KEY_PLUS) || (vlwwhcpxwopu == KEY_MINUS)) && (eshuyivywcyl->dehqyzmoyahd.lxnfhtpgqfci&0x20)) { eshuyivywcyl = &((const struct aaqxyrxbybvu*)eshuyivywcyl->dehqyzmoyahd.ovxhljuweifs)->shzveqsbwpgu;
bvjhgvfeltum = true;
} else if ((vlwwhcpxwopu == KEY_FAN) && (eshuyivywcyl->kheyzdjrjuew.lxnfhtpgqfci&0x20)) { eshuyivywcyl = &((const struct aaqxyrxbybvu*)eshuyivywcyl->kheyzdjrjuew.ovxhljuweifs)->shzveqsbwpgu;
bvjhgvfeltum = true;
} if (bvjhgvfeltum) { vfjfcbtuqghr = vyudfzxzxuqv;
if (!bc7215_ac_replace_base(rcmwutmxcidu, (const bc7215DataVarPkt_t*)&mkrbbjgfiafa)) { return NULL;
} } ragsgmpbksry[0] = hdwyeyojigbv;
ragsgmpbksry[1] = qzlsegpdwvuy;
ragsgmpbksry[2] = wuhswjqeidrw;
ragsgmpbksry[3] = vlwwhcpxwopu;
if (eshuyivywcyl != NULL) { if (!eshuyivywcyl->spec.gerxujbjmtkf) { zzttduzmzbrv = eshuyivywcyl->uuipfhjicnzd->set.tfdslecfsyog;
xkfkkucbfrcx = eshuyivywcyl->uuipfhjicnzd->set.jbfskexyzrhn;
eskpjhgjdyyb(zzttduzmzbrv, xkfkkucbfrcx);
zzttduzmzbrv = eshuyivywcyl->uuipfhjicnzd->set.hfvkajvenbnh;
xkfkkucbfrcx = eshuyivywcyl->uuipfhjicnzd->set.lsgevcqemhdh;
eskpjhgjdyyb(zzttduzmzbrv, xkfkkucbfrcx);
zzttduzmzbrv = eshuyivywcyl->uuipfhjicnzd->set.mfuegtfdfyhd;
xkfkkucbfrcx = eshuyivywcyl->uuipfhjicnzd->set.snygvnvbkdmu;
eskpjhgjdyyb(zzttduzmzbrv, xkfkkucbfrcx);
} wvephcqvrhxl[0] = 0;
wvephcqvrhxl[1] = 0;
wvephcqvrhxl[2] = 0;
wvephcqvrhxl[3] = 0;
if (ragsgmpbksry[0] >= 0) { wvephcqvrhxl[0] = pgxiavlktuhc(&eshuyivywcyl->dehqyzmoyahd, ragsgmpbksry[0], scdmdvhoqlof);
} if ((ragsgmpbksry[1] >= 0) && (ragsgmpbksry[1]<0x0f)) { wvephcqvrhxl[1] = pgxiavlktuhc(&eshuyivywcyl->fgstngnlzpzg, ragsgmpbksry[1], scdmdvhoqlof);
if (eshuyivywcyl->fgstngnlzpzg.lxnfhtpgqfci & 0x80) { ragsgmpbksry[3] = ragsgmpbksry[1];
} } if ((ragsgmpbksry[2] >= 0) && (ragsgmpbksry[2] < 0x0f)) { wvephcqvrhxl[2] = pgxiavlktuhc(&eshuyivywcyl->kheyzdjrjuew, ragsgmpbksry[2], scdmdvhoqlof);
if (eshuyivywcyl->kheyzdjrjuew.lxnfhtpgqfci & 0x80) { ragsgmpbksry[3] = ragsgmpbksry[2];
} } if ((ragsgmpbksry[3] >= 0) && (ragsgmpbksry[3]<0x0f)) { wvephcqvrhxl[3] = pgxiavlktuhc(&eshuyivywcyl->bgofcjmacpch, ragsgmpbksry[3], scdmdvhoqlof);
} if (eshuyivywcyl->uuipfhjicnzd->set.vrdfzsmcauwh != NULL) { odvdnwwbnbcv(eshuyivywcyl);
} gzhrykjwmzua(eshuyivywcyl, scdmdvhoqlof);
fefldogauyki(eshuyivywcyl);
cycwqtmggord(eshuyivywcyl);
if (bvjhgvfeltum) { eshuyivywcyl = untfwblhfxve;
if (!bc7215_ac_replace_base(qobvowrftgaq, (const bc7215DataVarPkt_t*)&vfjfcbtuqghr)) { return NULL;
} if (uohaukzjobju) { xlvdqneiksch.body.msg.fmt = &bmmyftuypsva;
xlvdqneiksch.body.msg.datPkt = (bc7215DataVarPkt_t*)&qlavfhidhmdq;
return (const bc7215DataVarPkt_t*)&xlvdqneiksch;
} } if (yvufzzwbxjjd) { xlvdqneiksch.body.msg.fmt = &jadyfbnomgtt;
xlvdqneiksch.body.msg.datPkt = (bc7215DataVarPkt_t*)&qlavfhidhmdq;
return (const bc7215DataVarPkt_t*)&xlvdqneiksch;
} else { return (const bc7215DataVarPkt_t*)&qlavfhidhmdq;
} } else { return  NULL;
} } static bool lcvfbnqxzxid(const bc7215DataVarPkt_t* npikivgkyypz) { const uint8_t* dgzuehpqovas;
uint16_t	bitLen;
struct ekojtdrzppcn tfdvcvkctfsw;
dgzuehpqovas = (const uint8_t*)eshuyivywcyl->vdjdiohbbbln.npikivgkyypz;
bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
if (bitLen == 0) { dgzuehpqovas += 2+33;
} bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
dgzuehpqovas += (bitLen+7)/8 + 2;
bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
if (bitLen != 0) { dgzuehpqovas += (bitLen+7)/8 + 2;
} else { dgzuehpqovas += 2;
} tfdvcvkctfsw.yfzeivmnnrai = *dgzuehpqovas;
tfdvcvkctfsw.mvclhuiimujy = *(dgzuehpqovas+1);
tfdvcvkctfsw.bits = *(dgzuehpqovas+2);
if ( npikivgkyypz->data[tfdvcvkctfsw.mvclhuiimujy] == scvmjwhwfhna[tfdvcvkctfsw.yfzeivmnnrai](npikivgkyypz->data[tfdvcvkctfsw.mvclhuiimujy], tfdvcvkctfsw.bits) ) { return true;
} else { return false;
} } const char* bc7215_ac_get_ver(void) { return VERSION;
} bool bc7215_ac_init(uint8_t gkiurtlomibv, const bc7215DataVarPkt_t* dataPktCool25C) { fpecgvzrimrg = false;
return owdzeookpdkt(gkiurtlomibv, dataPktCool25C);
} bool bc7215_ac_init_f(uint8_t gkiurtlomibv, const bc7215DataVarPkt_t* kgpwbqklmesf) { fpecgvzrimrg = true;
return owdzeookpdkt(gkiurtlomibv, kgpwbqklmesf);
} bool bc7215_ac_init2(uint8_t bpxhmqiavjwe, const bc7215CombinedMsg_t gjarldacwgah[], uint8_t oqmimngcikpd) { fpecgvzrimrg = false;
return akedehgcckgm(bpxhmqiavjwe, gjarldacwgah, oqmimngcikpd);
} bool bc7215_ac_init2_f(uint8_t bpxhmqiavjwe, const bc7215CombinedMsg_t gjarldacwgah[], uint8_t oqmimngcikpd) { fpecgvzrimrg = true;
return akedehgcckgm(bpxhmqiavjwe, gjarldacwgah, oqmimngcikpd);
} bool bc7215_ac_find_next(void) { uint16_t htodnioledof;
if (tvpnkcpbdlod >= 0) { if (yvufzzwbxjjd) { gnefjgqgcnln();
yvufzzwbxjjd = false;
}
#ifndef _NO_DEPRECATED
else if (((eshuyivywcyl->bgofcjmacpch.lxnfhtpgqfci&0xf0) == 0x80) && ekvawgrcfycz) { kfddmbndyzoa(eshuyivywcyl);
return true;
} else if ((eshuyivywcyl->bgofcjmacpch.lxnfhtpgqfci&0xf0) == 0xe0) { yvufzzwbxjjd = true;
return true;
}
#endif
for (htodnioledof=tvpnkcpbdlod+1; htodnioledof<ohhfkklvqouy; htodnioledof++)
{ if (aqnomkulnvqa(htodnioledof)) { tvpnkcpbdlod = htodnioledof;
return true;
} } } tvpnkcpbdlod = -1;
eshuyivywcyl = NULL;
return false;
} const bc7215DataVarPkt_t* bc7215_ac_set(int8_t piwtxpzhijzg, int8_t qzlsegpdwvuy, int8_t wuhswjqeidrw, int8_t vlwwhcpxwopu) { if (piwtxpzhijzg > 14) { piwtxpzhijzg = -1;
} if (qzlsegpdwvuy > MODE_FAN) { qzlsegpdwvuy = -1;
} if (wuhswjqeidrw > FAN_HIGH) { wuhswjqeidrw = -1;
} if (vlwwhcpxwopu > KEY_FAN) { vlwwhcpxwopu = -1;
} return glucnmhzseje(piwtxpzhijzg, qzlsegpdwvuy, wuhswjqeidrw, vlwwhcpxwopu);
} const bc7215DataVarPkt_t* bc7215_ac_set_f(int8_t baslfwtcahwv, int8_t qzlsegpdwvuy, int8_t wuhswjqeidrw, int8_t vlwwhcpxwopu) { int8_t	piwtxpzhijzg;
if (qzlsegpdwvuy > MODE_FAN) { qzlsegpdwvuy = -1;
} if (wuhswjqeidrw > FAN_HIGH) { wuhswjqeidrw = -1;
} if (vlwwhcpxwopu > KEY_FAN) { vlwwhcpxwopu = -1;
} if ((baslfwtcahwv < 0) || (baslfwtcahwv > 28)) { piwtxpzhijzg = -1;
} else { if (eshuyivywcyl->cjxibzuelnnx != NULL) { piwtxpzhijzg = eshuyivywcyl->cjxibzuelnnx->aejqufrcwkkq[baslfwtcahwv];
ychytxuxyzfe(&eshuyivywcyl->cjxibzuelnnx->xlfohizjsfwi, baslfwtcahwv, scdmdvhoqlof);
} else { piwtxpzhijzg = gculcshoavsy.aejqufrcwkkq[baslfwtcahwv];
} } return glucnmhzseje(piwtxpzhijzg, qzlsegpdwvuy, wuhswjqeidrw, vlwwhcpxwopu);
} const bc7215DataVarPkt_t* bc7215_ac_on(void) { uint16_t usspbezcydxn;
const uint8_t*	dgzuehpqovas;
if (tvpnkcpbdlod >= 0) { if (eshuyivywcyl->spec.uwhisdczmgip) { dgzuehpqovas = (const uint8_t*)eshuyivywcyl->vdjdiohbbbln.npikivgkyypz;
zloiimuniybf.bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
if (zloiimuniybf.bitLen != 0) { usspbezcydxn = (zloiimuniybf.bitLen+7)/8+2;
dgzuehpqovas = dgzuehpqovas+usspbezcydxn;
if ((*dgzuehpqovas != 0) || (*(dgzuehpqovas+1) != 0)) { zloiimuniybf.bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
memcpy(&zloiimuniybf.data, dgzuehpqovas+2, (zloiimuniybf.bitLen+7)/8);
if (yvufzzwbxjjd) { xlvdqneiksch.bitLen = 0;
xlvdqneiksch.body.msg.fmt = &jadyfbnomgtt;
xlvdqneiksch.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&zloiimuniybf);
return (const bc7215DataVarPkt_t*)&xlvdqneiksch;
} else { return (const bc7215DataVarPkt_t*)(&zloiimuniybf);
} } } else { dgzuehpqovas += 2;
memcpy(&hsygtmafbtdx, dgzuehpqovas, 33);
dgzuehpqovas += 33;
zloiimuniybf.bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
usspbezcydxn = (zloiimuniybf.bitLen+7)/8+2;
dgzuehpqovas += usspbezcydxn;
zloiimuniybf.bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
if (zloiimuniybf.bitLen != 0) { memcpy(&zloiimuniybf.data, dgzuehpqovas+2, (zloiimuniybf.bitLen+7)/8);
xlvdqneiksch.bitLen = 0;
xlvdqneiksch.body.msg.fmt = &hsygtmafbtdx;
xlvdqneiksch.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&zloiimuniybf);
return (const bc7215DataVarPkt_t*)&xlvdqneiksch;
} } } else if (eshuyivywcyl->spec.lrobawqzqmff || (!((eshuyivywcyl->dehqyzmoyahd.lxnfhtpgqfci | eshuyivywcyl->fgstngnlzpzg.lxnfhtpgqfci | eshuyivywcyl->kheyzdjrjuew.lxnfhtpgqfci)&0x80) && (eshuyivywcyl->bgofcjmacpch.ovxhljuweifs != NULL))) { return jtqzfrhqsowa(5);
} } return NULL;
} const bc7215DataVarPkt_t* bc7215_ac_off(void) { const uint8_t*	dgzuehpqovas;
if (tvpnkcpbdlod >= 0) { if (!eshuyivywcyl->spec.uwhisdczmgip) { return jtqzfrhqsowa(4);
} else { dgzuehpqovas = (const uint8_t*)eshuyivywcyl->vdjdiohbbbln.npikivgkyypz;
zloiimuniybf.bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
if (zloiimuniybf.bitLen != 0) { memcpy(&zloiimuniybf.data, dgzuehpqovas+2, (zloiimuniybf.bitLen+7)/8);
if (yvufzzwbxjjd) { xlvdqneiksch.bitLen = 0;
xlvdqneiksch.body.msg.fmt = &jadyfbnomgtt;
xlvdqneiksch.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&zloiimuniybf);
return (const bc7215DataVarPkt_t*)&xlvdqneiksch;
} else { return (const bc7215DataVarPkt_t*)(&zloiimuniybf);
} } else { dgzuehpqovas += 2;
memcpy(&hsygtmafbtdx, dgzuehpqovas, 33);
dgzuehpqovas += 33;
zloiimuniybf.bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
memcpy(&zloiimuniybf.data, dgzuehpqovas+2, (zloiimuniybf.bitLen+7)/8);
if (zloiimuniybf.bitLen != 0) { xlvdqneiksch.bitLen = 0;
xlvdqneiksch.body.msg.fmt = &hsygtmafbtdx;
xlvdqneiksch.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&zloiimuniybf);
return (const bc7215DataVarPkt_t*)&xlvdqneiksch;
} } } } return NULL;
} uint8_t bc7215_ac_predefined_cnt(void) { return jynelzyuxwhh;
} const bc7215DataVarPkt_t* bc7215_ac_predefined_data(uint8_t lkntswqvwxgi) { const uint8_t* dgzuehpqovas;
if (lkntswqvwxgi < jynelzyuxwhh) { dgzuehpqovas = (const uint8_t*)wtytkqyaghkq[lkntswqvwxgi];
zloiimuniybf.bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
memcpy(&zloiimuniybf.data, dgzuehpqovas+2, (zloiimuniybf.bitLen+7)/8);
return (const bc7215DataVarPkt_t*)&zloiimuniybf;
} else { return NULL;
} } const bc7215DataVarPkt_t* bc7215_ac_predefined_data_f(uint8_t lkntswqvwxgi) { const uint8_t* dgzuehpqovas;
if (lkntswqvwxgi < jynelzyuxwhh) { dgzuehpqovas = (const uint8_t*)vcsiwxyyfvux[lkntswqvwxgi];
zloiimuniybf.bitLen = ((*(dgzuehpqovas+1))<<8)+*dgzuehpqovas;
memcpy(&zloiimuniybf.data, dgzuehpqovas+2, (zloiimuniybf.bitLen+7)/8);
return (const bc7215DataVarPkt_t*)&zloiimuniybf;
} else { return NULL;
} } const bc7215FormatPkt_t* bc7215_ac_predefined_fmt(uint8_t lkntswqvwxgi) { if (lkntswqvwxgi < jynelzyuxwhh) { memcpy(&hsygtmafbtdx, ((const uint8_t*)&epnmnsekiecd)+33*lkntswqvwxgi, 33);
return &hsygtmafbtdx;
} else { return NULL;
} } const char* bc7215_ac_predefined_name(uint8_t lkntswqvwxgi) { if (lkntswqvwxgi < jynelzyuxwhh) { return zcdepxnlhfam[lkntswqvwxgi];
} else { return "";
} }
#ifndef _NO_DEPRECATED
uint8_t bc7215_ac_need_extra_sample(void) { uint8_t yiqmcmksqjww;
yiqmcmksqjww = 0;
if (eshuyivywcyl != NULL) { if (eshuyivywcyl->dehqyzmoyahd.lxnfhtpgqfci&0x20) { yiqmcmksqjww = 1;
} if (eshuyivywcyl->fgstngnlzpzg.lxnfhtpgqfci&0x20) { yiqmcmksqjww = 2;
} if (eshuyivywcyl->kheyzdjrjuew.lxnfhtpgqfci&0x20) { yiqmcmksqjww = 3;
} if (((eshuyivywcyl->bgofcjmacpch.lxnfhtpgqfci&0xf0) == 0xc0) ||(yvufzzwbxjjd && ((eshuyivywcyl->bgofcjmacpch.lxnfhtpgqfci&0xf0) == 0xe0))) { yiqmcmksqjww = 4;
} } return yiqmcmksqjww;
} bool bc7215_ac_save_2nd_base(uint8_t gkiurtlomibv, const bc7215CombinedMsg_t* message) { uint8_t bnvferxhyhpp;
if (!(gkiurtlomibv&0x80) && (message != NULL) && (message->body.msg.fmt->signature.bits.sig == (gkiurtlomibv&0x3f))) { bnvferxhyhpp = (message->body.msg.datPkt->bitLen+7)/8;
if (bnvferxhyhpp <= BC7215_MAX_RX_DATA_SIZE) { bmmyftuypsva = *message->body.msg.fmt;
uohaukzjobju = true;
rcmwutmxcidu = gkiurtlomibv;
mkrbbjgfiafa.bitLen = message->body.msg.datPkt->bitLen;
memcpy(mkrbbjgfiafa.data, message->body.msg.datPkt->data, bnvferxhyhpp);
return true;
} } return false;
} bc7215CombinedMsg_t bc7215_ac_get_2nd_base(void) { bc7215CombinedMsg_t jitvgptbpxow;
jitvgptbpxow.bitLen = 0;
jitvgptbpxow.body.msg.datPkt = (bc7215DataVarPkt_t*)&mkrbbjgfiafa;
jitvgptbpxow.body.msg.fmt = &bmmyftuypsva;
return jitvgptbpxow;
}
#endif
bool bc7215_ac_replace_base(uint8_t gkiurtlomibv, const bc7215DataVarPkt_t* lrjfvhctdyen) { uint8_t bnvferxhyhpp;
uint8_t ljfddxvtfevo;
if ((eshuyivywcyl != NULL) && (lrjfvhctdyen != NULL) && (lrjfvhctdyen->bitLen <= BC7215_MAX_RX_DATA_SIZE*8)) { if (lrjfvhctdyen->bitLen != 0) { if (!(gkiurtlomibv&0x80)) { bnvferxhyhpp = (lrjfvhctdyen->bitLen+7)/8;
if (lrjfvhctdyen->bitLen == eshuyivywcyl->bitLen) { memcpy(vyudfzxzxuqv.data, lrjfvhctdyen->data, bnvferxhyhpp);
qobvowrftgaq = gkiurtlomibv;
vyudfzxzxuqv.bitLen = lrjfvhctdyen->bitLen;
} else { memcpy(qlavfhidhmdq.data, lrjfvhctdyen->data, bnvferxhyhpp);
qlavfhidhmdq.bitLen = lrjfvhctdyen->bitLen;
pcybytxdfact = true;
return false;
} } else { return false;
} } else if ((gkiurtlomibv&0x3f) < 4) { ljfddxvtfevo = gkiurtlomibv&0x40;
if (pizpnixvzdav(gkiurtlomibv&0x3f, (const bc7215CombinedMsg_t*) lrjfvhctdyen)) { if (qlavfhidhmdq.bitLen == eshuyivywcyl->bitLen) { qobvowrftgaq = jadyfbnomgtt.signature.bits.sig | ljfddxvtfevo;
vyudfzxzxuqv = qlavfhidhmdq;
} else { pcybytxdfact = true;
return false;
} } else { return false;
} } else { return false;
} pcybytxdfact = false;
xfzwmuwzhapt(eshuyivywcyl, qobvowrftgaq, (const bc7215DataVarPkt_t*)&vyudfzxzxuqv);
if (gzhrykjwmzua(eshuyivywcyl, dblsytetyfke)) { return true;
} return false;
} else { return false;
} } const bc7215FormatPkt_t* bc7215_ac_get_base_fmt(void) { return &jadyfbnomgtt;
} const bc7215DataVarPkt_t* bc7215_ac_get_base_data(void) { return (bc7215DataVarPkt_t*)&vyudfzxzxuqv;
} uint8_t bc7215_ac_get_base_status(void) { return qobvowrftgaq;
} bool bc7215_ac_parse(int8_t* hdwyeyojigbv, int8_t* qzlsegpdwvuy, int8_t* wuhswjqeidrw, int8_t* nnvfuberprvf) { uint16_t	owajbmxrtymu=0;
uint16_t	zplfbtnkkrtf=0;
const bc7215DataVarPkt_t*	lsmrwsakfmem;
bool yiqmcmksqjww = false;
*hdwyeyojigbv = -1;
*qzlsegpdwvuy = -1;
*wuhswjqeidrw = -1;
*nnvfuberprvf = -1;
if (!pcybytxdfact) { yiqmcmksqjww = gzhrykjwmzua(eshuyivywcyl, dblsytetyfke);
if (yiqmcmksqjww) { *hdwyeyojigbv = dyziyowpoeky(&eshuyivywcyl->dehqyzmoyahd, 15);
*qzlsegpdwvuy = dyziyowpoeky(&eshuyivywcyl->fgstngnlzpzg, 5);
*wuhswjqeidrw = dyziyowpoeky(&eshuyivywcyl->kheyzdjrjuew, 4);
*nnvfuberprvf = pgbtxrtfvzpc(eshuyivywcyl);
} } else { if (eshuyivywcyl->spec.uwhisdczmgip) { lsmrwsakfmem = bc7215_ac_off();
if (lsmrwsakfmem != NULL) { if (lsmrwsakfmem->bitLen != 0) { zplfbtnkkrtf = lsmrwsakfmem->bitLen;
} else { zplfbtnkkrtf = ((const bc7215CombinedMsg_t*)lsmrwsakfmem)->body.msg.datPkt->bitLen;
} } lsmrwsakfmem = bc7215_ac_on();
if (lsmrwsakfmem != NULL) { if (lsmrwsakfmem->bitLen != 0) { owajbmxrtymu = lsmrwsakfmem->bitLen;
} else { owajbmxrtymu = ((const bc7215CombinedMsg_t*)lsmrwsakfmem)->body.msg.datPkt->bitLen;
} } if (zplfbtnkkrtf == qlavfhidhmdq.bitLen) { yiqmcmksqjww = true;
if (eshuyivywcyl->spec.lrobawqzqmff) { *nnvfuberprvf = 2;
} else if (owajbmxrtymu != zplfbtnkkrtf) { *nnvfuberprvf = 0;
} else if (lcvfbnqxzxid((bc7215DataVarPkt_t*)&qlavfhidhmdq)) { *nnvfuberprvf = 0;
} else { *nnvfuberprvf = 1;
} } else if (owajbmxrtymu == qlavfhidhmdq.bitLen) { yiqmcmksqjww = true;
*nnvfuberprvf = 1;
} } } return yiqmcmksqjww;
} bool bc7215_ac_parse_f(int8_t* baslfwtcahwv, int8_t* qzlsegpdwvuy, int8_t* wuhswjqeidrw, int8_t* nnvfuberprvf) { bool yiqmcmksqjww;
yiqmcmksqjww = bc7215_ac_parse(baslfwtcahwv, qzlsegpdwvuy, wuhswjqeidrw, nnvfuberprvf);
if (yiqmcmksqjww && (*baslfwtcahwv >= 0)) { if (eshuyivywcyl->cjxibzuelnnx != NULL) { *baslfwtcahwv = zevjgzewucqn(eshuyivywcyl->cjxibzuelnnx);
} else { *baslfwtcahwv = zevjgzewucqn(&gculcshoavsy);
} } return yiqmcmksqjww;
}